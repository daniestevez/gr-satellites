<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>100</value></param>
<param><key>minsize</key><value>100</value></param>
</block>
<block>
<key>satellites_space_packet_parser</key>
<param><key>id</key><value>satellites_space_packet_parser_0</value></param>
</block>
<block>
<key>satellites_space_packet_primaryheader_adder</key>
<param><key>id</key><value>satellites_space_packet_primaryheader_adder_0</value></param>
<param><key>AP_ID</key><value>0</value></param>
<param><key>packet_type</key><value>0</value></param>
<param><key>secondary_header_flag</key><value>1</value></param>
</block>
<block>
<key>satellites_space_packet_time_stamp_adder</key>
<param><key>id</key><value>satellites_space_packet_time_stamp_adder_0</value></param>
<param><key>additional_octets_basic_time_cuc</key><value>3</value></param>
<param><key>additional_octets_fractional_time_cuc</key><value>3</value></param>
<param><key>basic_time_num_octets_cuc</key><value>3</value></param>
<param><key>calendar_variation_ccs</key><value>0</value></param>
<param><key>day</key><value>1</value></param>
<param><key>epoch_day_cds</key><value>0</value></param>
<param><key>epoch_day_cuc</key><value>0</value></param>
<param><key>epoch_month_cds</key><value>0</value></param>
<param><key>epoch_month_cuc</key><value>0</value></param>
<param><key>epoch_year_cds</key><value>0</value></param>
<param><key>epoch_year_cuc</key><value>0</value></param>
<param><key>fractional_time_num_octets_cuc</key><value>3</value></param>
<param><key>hour</key><value>1</value></param>
<param><key>length_of_day_cds</key><value>0</value></param>
<param><key>length_of_submillisecond_cds</key><value>0</value></param>
<param><key>manual_automatic</key><value>1</value></param>
<param><key>microsecond</key><value>1</value></param>
<param><key>minute</key><value>1</value></param>
<param><key>month</key><value>1</value></param>
<param><key>number_of_subsecond_ccs</key><value>2</value></param>
<param><key>pfield_extension_extended</key><value>0</value></param>
<param><key>pfield_extension</key><value>0</value></param>
<param><key>pfield</key><value>0</value></param>
<param><key>second</key><value>1</value></param>
<param><key>time_code_identification_cuc</key><value>1</value></param>
<param><key>time_format</key><value>0</value></param>
<param><key>year</key><value>2000</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>satellites_space_packet_time_stamp_adder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_space_packet_primaryheader_adder_0</source_block_id><sink_block_id>satellites_space_packet_parser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_space_packet_time_stamp_adder_0</source_block_id><sink_block_id>satellites_space_packet_primaryheader_adder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
