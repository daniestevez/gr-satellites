options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: doppler_correction_example
    output_language: python
    title: Doppler Correction example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: samp_rate//100
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    type: complex
  states: {}
- name: satellites_doppler_correction_0
  id: satellites_doppler_correction
  parameters:
    file: doppler_file.txt
    samp_rate: samp_rate
    t0: '0'
  states: {}

connections:
- [analog_const_source_x_0, '0', satellites_doppler_correction_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [satellites_doppler_correction_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
