options:
  parameters:
    author: Daniel Estevez
    copyright: 2020 Daniel Estevez <daniel@destevez.net>
    generate_options: hb_qt_gui
    id: qo100_multimedia_beacon
    output_language: python
    run_options: run
    title: QO-100 multimedia beacon RX
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: constellation_8apsk
  id: variable_constellation
  parameters:
    const_points: sym_points
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '7'
    sym_map: sym_map
    type: calcdist
  states: {}
- name: nfilt
  id: variable
  parameters:
    value: '64'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilt, nfilt, 1.0/sps, 0.2, int(ceil(15*sps*nfilt)))
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baudrate
  states: {}
- name: sym_map
  id: variable
  parameters:
    value: '[0b000, 0b100, 0b001, 0b011, 0b010, 0b110, 0b111, 0b101]'
  states: {}
- name: sym_map_inv
  id: variable
  parameters:
    value: '[sym_map.index(a) for a in range(8)]'
  states: {}
- name: sym_points
  id: variable
  parameters:
    value: '[0] + list(np.exp(1j*2*np.pi*np.arange(7)/7) * np.sqrt(8/7))'
  states: {}
- name: syncword_bits
  id: variable
  parameters:
    value: '''010100111110000110100110'''
  states: {}
- name: syncword_symbols
  id: variable
  parameters:
    value: '[sym_points[sym_map.index(a)] for a in [2, 4, 7, 6, 0, 6, 4, 6]]'
  states: {}
- name: syncword_threshold
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(1j*2*np.pi/7)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(1j*2*np.pi*2/7)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(1j*2*np.pi*5/7)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(1j*2*np.pi*3/7)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(1j*2*np.pi*6/7)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(1j*2*np.pi*4/7)
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: blocks_unpack_k_bits_bb_0_2
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_8apsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_8apsk
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_8apsk
  states: {}
- name: digital_constellation_decoder_cb_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_8apsk
  states: {}
- name: digital_constellation_decoder_cb_0_1_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_8apsk
  states: {}
- name: digital_constellation_decoder_cb_0_1_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_8apsk
  states: {}
- name: digital_constellation_decoder_cb_0_2
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_8apsk
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: sym_map
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: sym_map
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: sym_map
  states: {}
- name: digital_map_bb_0_1
  id: digital_map_bb
  parameters:
    map: sym_map
  states: {}
- name: digital_map_bb_0_1_0
  id: digital_map_bb
  parameters:
    map: sym_map
  states: {}
- name: digital_map_bb_0_1_0_0
  id: digital_map_bb
  parameters:
    map: sym_map
  states: {}
- name: digital_map_bb_0_2
  id: digital_map_bb
  parameters:
    map: sym_map
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.005'
    max_dev: '0.01'
    nfilters: nfilt
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '0.5'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: files_path
  id: parameter
  parameters:
    label: Files path
    type: str
    value: /tmp/
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: np.conjugate(syncword_symbols)[::-1]
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import ceil
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,1,1,1
    legend: 'False'
    name: 8APSK constellation
    size: int(0.5*baudrate)
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha2: '0.25'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,1,1
    label1: Signal
    label2: Mirrored signal
    name: Spectrum
    nconnections: '2'
    type: complex
    ymax: '-20'
    ymin: '-70'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,2
    label1: I
    label2: Q
    label3: Amplitude
    name: Syncword correlation
    nconnections: '3'
    size: (255+3)*8//3*2
    srate: baudrate
    type: float
    ymax: '10'
    ymin: '-10'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: '6000'
  states: {}
- name: satellites_costas_loop_8apsk_cc_0
  id: satellites_costas_loop_8apsk_cc
  parameters:
    loop_bw: '0.02'
  states: {}
- name: satellites_crc_check_0
  id: satellites_crc_check
  parameters:
    discard_crc: 'True'
    final_xor: '0x0000'
    initial_value: '0xFFFF'
    num_bits: '16'
    poly: '0x1021'
  states: {}
- name: satellites_decode_rs_0
  id: satellites_decode_rs
  parameters:
    fcr: '120'
    gfpoly: '0x187'
    interleave: '1'
    nroots: '32'
    nsym: '8'
    prim: '1'
  states: {}
- name: satellites_file_receiver_0
  id: satellites_file_receiver
  parameters:
    path: files_path
    receiver: qo100_multimedia
    verbose: 'True'
  states: {}
- name: satellites_pdu_scrambler_0
  id: satellites_pdu_scrambler
  parameters:
    sequence: '[130, 239, 223, 19, 146, 254, 12, 86, 106, 68, 77, 213, 243, 216, 102, 227, 108, 113, 229, 89, 26, 64, 138, 216, 225, 121, 194, 137, 152, 64, 51, 175, 68, 200, 37, 104, 247, 68, 193, 50, 19, 14, 196, 81, 4, 236, 191, 249, 83, 25, 161, 171, 167, 29, 33, 139, 7, 152, 230, 144, 125, 206, 34, 236, 112, 78, 219, 34, 181, 161, 7, 45, 198, 235, 62, 115, 194, 100, 209, 95, 186, 161, 53, 10, 110, 246, 122, 246, 207, 194, 178, 63, 232, 93, 158, 234, 231, 73, 214, 64, 130, 239, 223, 19, 146, 254, 12, 86, 106, 68, 77, 213, 243, 216, 102, 227, 108, 113, 229, 89, 26, 64, 138, 216, 225, 121, 194, 137, 152, 64, 51, 175, 68, 200, 37, 104, 247, 68, 193, 50, 19, 14, 196, 81, 4, 236, 191, 249, 83, 25, 161, 171, 167, 29, 33, 139, 7, 152, 230, 144, 125, 206, 34, 236, 112, 78, 219, 34, 181, 161, 7, 45, 198, 235, 62, 115, 194, 100, 209, 95, 186, 161, 53, 10, 110, 246, 122, 246, 207, 194, 178, 63, 232, 93, 158, 234, 231, 73, 214, 64, 130, 239, 223, 19, 146, 254, 12, 86, 106, 68, 77, 213, 243, 216, 102, 227, 108, 113, 229, 89, 26, 64, 138, 216, 225, 121, 194, 137, 152, 64, 51, 175, 68, 200, 37, 104, 247, 68, 193, 50, 19, 14, 196, 81, 4, 236, 191, 249, 83, 25, 161, 171, 167, 29, 33, 139, 7, 152, 230, 144, 125, 206, 34, 236, 112, 78, 219, 34, 181, 161, 7, 45, 198, 235, 62, 115, 194, 100, 209, 95, 186, 161, 53, 10, 110, 246, 122, 246, 207, 194, 178, 63, 232, 93, 158, 234, 231, 73, 214, 64, 130, 239, 223, 19, 146, 254, 12, 86, 106, 68, 77, 213, 243, 216, 102, 227, 108, 113, 229, 89, 26, 64, 138, 216, 225, 121, 194, 137, 152, 64, 51, 175, 68, 200, 37, 104, 247, 68, 193, 50, 19, 14, 196, 81, 4, 236, 191, 249, 83, 25, 161, 171, 167, 29, 33, 139, 7, 152, 230, 144, 125, 206, 34, 236, 112, 78, 219, 34, 181, 161, 7, 45, 198, 235, 62, 115, 194, 100, 209, 95, 186, 161, 53, 10, 110, 246, 122, 246, 207, 194, 178, 63, 232, 93, 158, 234, 231, 73, 214, 64]'
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '255'
    sync: syncword_bits
    threshold: syncword_threshold
  states: {}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '255'
    sync: syncword_bits
    threshold: syncword_threshold
  states: {}
- name: satellites_sync_to_pdu_packed_0_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '255'
    sync: syncword_bits
    threshold: syncword_threshold
  states: {}
- name: satellites_sync_to_pdu_packed_0_1
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '255'
    sync: syncword_bits
    threshold: syncword_threshold
  states: {}
- name: satellites_sync_to_pdu_packed_0_1_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '255'
    sync: syncword_bits
    threshold: syncword_threshold
  states: {}
- name: satellites_sync_to_pdu_packed_0_1_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '255'
    sync: syncword_bits
    threshold: syncword_threshold
  states: {}
- name: satellites_sync_to_pdu_packed_0_2
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '255'
    sync: syncword_bits
    threshold: syncword_threshold
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_conjugate_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', digital_constellation_decoder_cb_0_1, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', digital_constellation_decoder_cb_0_1_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', digital_constellation_decoder_cb_0_2, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', digital_constellation_decoder_cb_0_1_0_0, '0']
- [blocks_multiply_const_vxx_0_2, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', satellites_sync_to_pdu_packed_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', satellites_sync_to_pdu_packed_0_1, '0']
- [blocks_unpack_k_bits_bb_0_1_0, '0', satellites_sync_to_pdu_packed_0_1_0, '0']
- [blocks_unpack_k_bits_bb_0_1_0_0, '0', satellites_sync_to_pdu_packed_0_1_0_0, '0']
- [blocks_unpack_k_bits_bb_0_2, '0', satellites_sync_to_pdu_packed_0_2, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_map_bb_0_0_0, '0']
- [digital_constellation_decoder_cb_0_1, '0', digital_map_bb_0_1, '0']
- [digital_constellation_decoder_cb_0_1_0, '0', digital_map_bb_0_1_0, '0']
- [digital_constellation_decoder_cb_0_1_0_0, '0', digital_map_bb_0_1_0_0, '0']
- [digital_constellation_decoder_cb_0_2, '0', digital_map_bb_0_2, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_map_bb_0_1, '0', blocks_unpack_k_bits_bb_0_1, '0']
- [digital_map_bb_0_1_0, '0', blocks_unpack_k_bits_bb_0_1_0, '0']
- [digital_map_bb_0_1_0_0, '0', blocks_unpack_k_bits_bb_0_1_0_0, '0']
- [digital_map_bb_0_2, '0', blocks_unpack_k_bits_bb_0_2, '0']
- [digital_symbol_sync_xx_0, '0', satellites_costas_loop_8apsk_cc_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_float_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [pad_source_0, '0', satellites_rms_agc_0, '0']
- [satellites_costas_loop_8apsk_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [satellites_costas_loop_8apsk_cc_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [satellites_costas_loop_8apsk_cc_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [satellites_costas_loop_8apsk_cc_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [satellites_costas_loop_8apsk_cc_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [satellites_costas_loop_8apsk_cc_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [satellites_costas_loop_8apsk_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [satellites_costas_loop_8apsk_cc_0, '0', fir_filter_xxx_0, '0']
- [satellites_costas_loop_8apsk_cc_0, '0', qtgui_const_sink_x_0, '0']
- [satellites_crc_check_0, ok, blocks_socket_pdu_0, pdus]
- [satellites_crc_check_0, ok, satellites_file_receiver_0, in]
- [satellites_decode_rs_0, out, satellites_crc_check_0, in]
- [satellites_pdu_scrambler_0, out, satellites_decode_rs_0, in]
- [satellites_rms_agc_0, '0', blocks_conjugate_cc_0, '0']
- [satellites_rms_agc_0, '0', digital_symbol_sync_xx_0, '0']
- [satellites_rms_agc_0, '0', qtgui_freq_sink_x_0, '0']
- [satellites_sync_to_pdu_packed_0, out, satellites_pdu_scrambler_0, in]
- [satellites_sync_to_pdu_packed_0_0, out, satellites_pdu_scrambler_0, in]
- [satellites_sync_to_pdu_packed_0_0_0, out, satellites_pdu_scrambler_0, in]
- [satellites_sync_to_pdu_packed_0_1, out, satellites_pdu_scrambler_0, in]
- [satellites_sync_to_pdu_packed_0_1_0, out, satellites_pdu_scrambler_0, in]
- [satellites_sync_to_pdu_packed_0_1_0_0, out, satellites_pdu_scrambler_0, in]
- [satellites_sync_to_pdu_packed_0_2, out, satellites_pdu_scrambler_0, in]

metadata:
  file_format: 1
