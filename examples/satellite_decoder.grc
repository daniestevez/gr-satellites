options:
  parameters:
    author: Daniel Estevez
    copyright: Daniel Estevez
    generate_options: no_gui
    id: satellite_decoder
    output_language: python
    run_options: run
    title: Satellite decoder example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/daniel/1kuns/1kuns_image_thumb1.wav
    repeat: 'False'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: name
    file: /usr/local/lib/python3/dist-packages/satellites/satyaml/1KUNS-PF.yml
    name: 1KUNS-PF
    norad: '99999'
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_wavfile_source_0, '0', satellites_satellite_decoder_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
