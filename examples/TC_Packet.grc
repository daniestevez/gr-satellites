<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>4</value></param>
<param><key>maxsize</key><value>8</value></param>
<param><key>minsize</key><value>8</value></param>
</block>
<block>
<key>satellites_telecommand_parser</key>
<param><key>id</key><value>satellites_telecommand_parser_0</value></param>
</block>
<block>
<key>satellites_telecommand_primaryheader_adder</key>
<param><key>id</key><value>satellites_telecommand_primaryheader_adder_0</value></param>
<param><key>bypass</key><value>0</value></param>
<param><key>control</key><value>0</value></param>
<param><key>spacecraft_id</key><value>0</value></param>
<param><key>virtual_channel_id</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>satellites_telecommand_primaryheader_adder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_telecommand_primaryheader_adder_0</source_block_id><sink_block_id>satellites_telecommand_parser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
