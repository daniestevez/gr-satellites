options:
  parameters:
    author: Daniel Estevez
    description: K2SAT S-band image decoder
    generate_options: qt_gui
    id: k2sat_image
    output_language: python
    title: K2SAT S-band image decoder
  states: {}

blocks:
- name: lowpass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 4*100e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 4*10e3
    win: window.WIN_HAMMING
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(samp_per_sym), 0.35, 11*samp_per_sym*nfilts)
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: syncword
  id: variable
  parameters:
    value: '"0101010101111110"'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/samp_rate_2M_photo_data_finalpacket_2
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_costas_loop_cc_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.01'
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.005'
    max_dev: '0.001'
    osps: '1'
    sps: samp_per_sym
    taps: rrc_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 500e3  + 0*138e3/4
    decim: '1'
    samp_rate: samp_rate
    taps: lowpass_taps
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: satellites_image_receiver_0
  id: satellites_image_receiver
  parameters:
    fullscreen: 'True'
    path: /tmp/
    receiver: k2sat
    verbose: 'True'
  states: {}
- name: satellites_k2sat_deframer_component_0
  id: satellites_k2sat_deframer_component
  parameters:
    threshold: '0'
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '0.5'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_interleave_0, '0', satellites_k2sat_deframer_component_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_costas_loop_cc_1, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', blocks_complex_to_float_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_const_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_rms_agc_0, '0']
- [satellites_k2sat_deframer_component_0, out, satellites_image_receiver_0, in]
- [satellites_rms_agc_0, '0', digital_costas_loop_cc_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-75-g67e88516
