options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: move2
    output_language: python
    title: MOVE-2 decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: noise_sigma
  id: variable
  parameters:
    comment: Used for LDPC decoding
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '78125'
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''49E0DCC7'''
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1.0'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '-0.5'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/gqrx_20231221_150159_145942500_78125_MOVE-II.raw
    length: int(2 * samp_rate)
    offset: int(281 * samp_rate)
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Convert to LLR
    const: '-2.0 / noise_sigma**2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '128'
    type: byte
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate * 10
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: byte
  states: {}
- name: digital_additive_scrambler_bb_0_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '2048'
    len: '7'
    mask: '0xA9'
    reset_tag_key: ''
    seed: '0xFF'
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: ldpc_toolbox_ldpc_decoder_0
  id: ldpc_toolbox_ldpc_decoder
  parameters:
    alist: /tmp/ccsds_1_2_1024.alist
    implementation: '''Phif64'''
    k: '1024'
    max_iterations: '200'
    n: '2048'
    puncturing: 1,1,1,1,0
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Symbols
    label2: Syncword correlation
    marker1: '0'
    nconnections: '2'
    size: int(baudrate * 2)
    srate: baudrate
    style1: '0'
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: satellites_bpsk_demodulator_0
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: baudrate
    differential: 'False'
    f_offset: '9400'
    iq: 'True'
    manchester: 'False'
    options: '"--disable_fll"'
    samp_rate: samp_rate
  states: {}
- name: satellites_nanolink_transport_0
  id: satellites_nanolink_transport
  parameters:
    options: '""'
  states: {}
- name: satellites_sync_to_pdu_soft_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '2048'
    sync: access_code
    threshold: '4'
  states: {}
- name: satellites_sync_to_pdu_soft_0_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: '2048'
    sync: access_code
    threshold: '4'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', satellites_sync_to_pdu_soft_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_stream_to_vector_1, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_null_source_0, '0', digital_additive_scrambler_bb_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_tag_gate_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_vector_1, '0', ldpc_toolbox_ldpc_decoder_0, '0']
- [blocks_tag_gate_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_throttle2_0, '0', satellites_bpsk_demodulator_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_additive_scrambler_bb_0_0, '0', blocks_char_to_float_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0, '1']
- [ldpc_toolbox_ldpc_decoder_0, '0', blocks_vector_to_stream_0_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_multiply_xx_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_nanolink_transport_0, in]
- [satellites_bpsk_demodulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [satellites_bpsk_demodulator_0, '0', fir_filter_xxx_1, '0']
- [satellites_bpsk_demodulator_0, '0', qtgui_time_sink_x_0, '0']
- [satellites_bpsk_demodulator_0, '0', satellites_sync_to_pdu_soft_0, '0']
- [satellites_nanolink_transport_0, out, blocks_message_debug_0, print]
- [satellites_sync_to_pdu_soft_0, out, pdu_pdu_to_tagged_stream_1, pdus]
- [satellites_sync_to_pdu_soft_0_0, out, pdu_pdu_to_tagged_stream_1, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
