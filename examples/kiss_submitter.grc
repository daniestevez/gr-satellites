options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: KISS client telemetry submitter
    generate_options: qt_gui
    id: kiss_submitter
    output_language: python
    run_options: run
    title: KISS client telemetry submitter
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: host
  id: parameter
  parameters:
    label: Host
    type: str
    value: localhost
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: host
    mtu: '10000'
    port: port
    type: TCP_CLIENT
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: localhost
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {}
- name: norad
  id: parameter
  parameters:
    label: NORAD ID
    type: intx
    value: '0'
  states: {}
- name: note_0
  id: note
  parameters:
    note: IP of SoundModem Source
  states: {}
- name: note_1
  id: note
  parameters:
    note: KISS port in SoundModem
  states: {}
- name: note_3
  id: note
  parameters:
    note: Output to GETKISS
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: port
  id: parameter
  parameters:
    label: Port
    short_id: p
    type: str
    value: '8001'
  states: {}
- name: recstart
  id: parameter
  parameters:
    label: start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)
    type: str
    value: ''
  states: {}
- name: satellites_kiss_to_pdu_0
  id: satellites_kiss_to_pdu
  parameters:
    control_byte: 'True'
  states: {}
- name: satellites_pdu_to_kiss_0
  id: satellites_pdu_to_kiss
  parameters:
    control_byte: 'True'
    include_timestamp: 'False'
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: norad
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {state: disabled}

connections:
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', satellites_kiss_to_pdu_0, '0']
- [satellites_kiss_to_pdu_0, out, satellites_pdu_to_kiss_0, in]
- [satellites_kiss_to_pdu_0, out, satellites_print_timestamp_0, in]
- [satellites_pdu_to_kiss_0, out, network_socket_pdu_1, pdus]
- [satellites_print_timestamp_0, out, blocks_message_debug_0, print_pdu]
- [satellites_print_timestamp_0, out, satellites_submit_0, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-75-g67e88516
