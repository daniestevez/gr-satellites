<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tm_packet_with_space_packet</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>2</value></param>
<param><key>minsize</key><value>2</value></param>
</block>
<block>
<key>satellites_space_packet_parser</key>
<param><key>id</key><value>satellites_space_packet_parser_0</value></param>
<param><key>time_header</key><value>1</value></param>
</block>
<block>
<key>satellites_space_packet_primaryheader_adder</key>
<param><key>id</key><value>satellites_space_packet_primaryheader_adder_0</value></param>
<param><key>AP_ID</key><value>0</value></param>
<param><key>packet_type</key><value>0</value></param>
<param><key>secondary_header_flag</key><value>1</value></param>
</block>
<block>
<key>satellites_telemetry_packet_reconstruction</key>
<param><key>id</key><value>satellites_telemetry_packet_reconstruction_0</value></param>
</block>
<block>
<key>satellites_telemetry_parser</key>
<param><key>id</key><value>satellites_telemetry_parser_0</value></param>
</block>
<block>
<key>satellites_telemetry_primaryheader_adder</key>
<param><key>id</key><value>satellites_telemetry_primaryheader_adder_0</value></param>
<param><key>coding</key><value>1</value></param>
<param><key>master_channel_frame_count</key><value>0</value></param>
<param><key>ocf_flag</key><value>0</value></param>
<param><key>packet_order_flag</key><value>1</value></param>
<param><key>segment_length_id</key><value>0</value></param>
<param><key>size</key><value>8</value></param>
<param><key>spacecraft_id</key><value>0</value></param>
<param><key>synch_flag</key><value>1</value></param>
<param><key>transfer_frame_secondary_header_flag</key><value>1</value></param>
<param><key>virtual_channel_frame_count</key><value>0</value></param>
<param><key>virtual_channel_id</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>satellites_space_packet_primaryheader_adder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_space_packet_primaryheader_adder_0</source_block_id><sink_block_id>satellites_telemetry_primaryheader_adder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_telemetry_packet_reconstruction_0</source_block_id><sink_block_id>satellites_space_packet_parser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_telemetry_parser_0</source_block_id><sink_block_id>satellites_telemetry_packet_reconstruction_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_telemetry_primaryheader_adder_0</source_block_id><sink_block_id>satellites_telemetry_parser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
