options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: ao40_fec_deframer
    output_language: python
    run_options: run
    title: AO-40 FEC deframer component example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ../../satellite-recordings/ao73.wav
    repeat: 'False'
  states: {}
- name: satellites_ao40_fec_deframer_0
  id: satellites_ao40_fec_deframer
  parameters:
    crc: 'False'
    short_frames: 'False'
    threshold: '8'
  states: {}
- name: satellites_bpsk_demodulator_0
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: '1200'
    differential: 'True'
    f_offset: '1500'
    manchester: 'False'
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_wavfile_source_0, '0', satellites_bpsk_demodulator_0, '0']
- [satellites_ao40_fec_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_bpsk_demodulator_0, '0', satellites_ao40_fec_deframer_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-75-g67e88516
