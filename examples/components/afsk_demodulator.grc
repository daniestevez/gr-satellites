options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: afsk_demodulator
    output_language: python
    title: AFSK demodulator component example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '8000'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ../../satellite-recordings/gomx_1.wav
    repeat: 'False'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '6000'
    srate: '4800'
    style1: '0'
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: satellites_afsk_demodulator_0
  id: satellites_afsk_demodulator
  parameters:
    af_carrier: '3600'
    baudrate: '4800'
    deviation: '-1200'
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_head_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', satellites_afsk_demodulator_0, '0']
- [satellites_afsk_demodulator_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
