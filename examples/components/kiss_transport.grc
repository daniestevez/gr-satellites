options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: kiss_transport
    output_language: python
    run_options: run
    title: KISS Transport component example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ../../satellite-recordings/by701.wav
    repeat: 'False'
  states: {}
- name: satellites_bpsk_demodulator_0
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: '9600'
    differential: 'False'
    f_offset: '12000'
    manchester: 'False'
    samp_rate: samp_rate
  states: {}
- name: satellites_ccsds_concatenated_deframer_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    differential: 'True'
    dual_basis: 'False'
    frame_size: '114'
    threshold: '4'
  states: {}
- name: satellites_kiss_transport_0
  id: satellites_kiss_transport
  parameters:
    use_control: 'False'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', satellites_bpsk_demodulator_0, '0']
- [satellites_bpsk_demodulator_0, '0', satellites_ccsds_concatenated_deframer_0, '0']
- [satellites_ccsds_concatenated_deframer_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_ccsds_concatenated_deframer_0, out, satellites_kiss_transport_0, in]
- [satellites_kiss_transport_0, out, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
