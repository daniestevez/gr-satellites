options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: fsk_demodulator
    output_language: python
    title: FSK demodulator component example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ../../satellite-recordings/aausat_4.wav
    repeat: 'False'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '12000'
    srate: '4800'
    style1: '0'
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '4800'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', satellites_fsk_demodulator_0, '0']
- [satellites_fsk_demodulator_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-75-g67e88516
