options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: u482c_deframer
    output_language: python
    run_options: run
    title: GOMspace U482C deframer component example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ../../satellite-recordings/gomx_1.wav
    repeat: 'False'
  states: {}
- name: satellites_afsk_demodulator_0_0
  id: satellites_afsk_demodulator
  parameters:
    af_carrier: '3600'
    baudrate: '4800'
    deviation: '-1200'
    samp_rate: samp_rate
  states: {}
- name: satellites_u482c_deframer_0
  id: satellites_u482c_deframer
  parameters:
    threshold: '4'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', satellites_afsk_demodulator_0_0, '0']
- [satellites_afsk_demodulator_0_0, '0', satellites_u482c_deframer_0, '0']
- [satellites_u482c_deframer_0, out, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-75-g67e88516
