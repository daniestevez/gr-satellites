options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: image_receiver
    output_language: python
    run_options: run
    title: Image receiver component example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ../../satellite-recordings/lilacsat1-image.wav
    repeat: 'False'
  states: {}
- name: satellites_image_receiver_0
  id: satellites_image_receiver
  parameters:
    fullscreen: 'True'
    path: /tmp/
    receiver: by70_1
    verbose: 'True'
  states: {}
- name: satellites_kiss_transport_0
  id: satellites_kiss_transport
  parameters:
    use_control: 'False'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: name
    name: LilacSat-1
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_throttle_0, '0', satellites_satellite_decoder_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [satellites_kiss_transport_0, out, satellites_image_receiver_0, in]
- [satellites_satellite_decoder_0, out, satellites_kiss_transport_0, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-75-g67e88516
