options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: ax100_deframer
    output_language: python
    run_options: run
    title: GOMspace AX100 deframer component example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ../../satellite-recordings/1kuns_pf.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: ../../satellite-recordings/tw_1b.wav
    repeat: 'False'
  states: {}
- name: note_0
  id: note
  parameters:
    note: ASM+Golay mode
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Reed-Solomon mode
  states: {}
- name: satellites_ax100_deframer_0
  id: satellites_ax100_deframer
  parameters:
    mode: '"ASM"'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: satellites_ax100_deframer_0_0
  id: satellites_ax100_deframer
  parameters:
    mode: '"RS"'
    threshold: '4'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '1200'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_fsk_demodulator_0_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '4800'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', satellites_fsk_demodulator_0, '0']
- [blocks_wavfile_source_0_0, '0', satellites_fsk_demodulator_0_0, '0']
- [satellites_ax100_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_ax100_deframer_0_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_fsk_demodulator_0, '0', satellites_ax100_deframer_0, '0']
- [satellites_fsk_demodulator_0_0, '0', satellites_ax100_deframer_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-75-g67e88516
