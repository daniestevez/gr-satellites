options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: ccsds_deframer
    output_language: python
    run_options: run
    title: CCSDS Concatenated deframer component example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ../../satellite-recordings/by701.wav
    repeat: 'False'
  states: {}
- name: satellites_bpsk_demodulator_0
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: '9600'
    differential: 'False'
    f_offset: '12000'
    manchester: 'False'
    options: ''
    samp_rate: samp_rate
  states: {}
- name: satellites_ccsds_concatenated_deframer_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: '114'
    precoding: '"differential"'
    rs_basis: '"conventional"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', satellites_bpsk_demodulator_0, '0']
- [satellites_bpsk_demodulator_0, '0', satellites_ccsds_concatenated_deframer_0, '0']
- [satellites_ccsds_concatenated_deframer_0, out, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
