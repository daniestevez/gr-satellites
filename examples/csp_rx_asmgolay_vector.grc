options:
  parameters:
    description: A simpmle test case of ASM + variable length packets
    generate_options: no_gui
    id: rx_asmgolay_vector
    output_language: python
    title: Variable Length Packet Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: T0
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0_0_0
  id: blocks_tag_debug
  parameters:
    name: T1
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1/8.0
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: ASM+Golay
    repeat: 'False'
    type: byte
    vector: '[1,0,0,1,0,0,1,1,0,0,0,0,1,0,1,1,0,1,0,1,0,0,0,1,1,1,0,1,1,1,1,0,0,1,0,1,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,1,0,1,1,0,0,0,1,0,1,0,1,0,1,0,0,0,0,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,0,0,1,0,0,1,1,0,0,0,0,1,0,1,1,0,1,0,1,0,0,0,1,1,1,0,1,1,1,1,0,0,1,0,1,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,1,0,1,1,0,0,0,1,0,1,0,1,0,1,0,0,0,0,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,]'
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: ASM+Golay+Randomization
    repeat: 'False'
    type: byte
    vector: '[1,0,0,1,0,0,1,1,0,0,0,0,1,0,1,1,0,1,0,1,0,0,0,1,1,1,0,1,1,1,1,0,0,1,0,1,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,1,0,1,0,1,1,1,0,1,0,1,1,1,1,0,1,0,0,0,0,1,1,0,0,0,0,0,1,1,0,0,0,0,0,0,1,0,0,1,1,0,1,0]'
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    comment: ASM+Golay+a 5 byte packet of all zeros
    repeat: 'False'
    type: byte
    vector: '[1,0,0,1,0,0,1,1,0,0,0,0,1,0,1,1,0,1,0,1,0,0,0,1,1,1,0,1,1,1,1,0,0,1,0,1,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0]'
  states: {}
- name: digital_additive_scrambler_bb_0_0_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0xA9'
    reset_tag_key: '"packet_len"'
    seed: '0xff'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10010011000010110101000111011110'
    tagname: syncword
    threshold: '6'
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: satellites_print_header_0
  id: satellites_print_header
  parameters: {}
  states: {state: disabled}
- name: satellites_varlen_packet_tagger_1
  id: satellites_varlen_packet_tagger
  parameters:
    endianness: int(gr.GR_MSB_FIRST)
    length_field_size: '55'
    maxoutbuf: '40'
    mtu: 255*8
    packetlen_tag: packet_len
    syncword_tag: syncword
    use_golay: 'True'
  states: {}

connections:
- [blocks_tagged_stream_multiply_length_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_vector_source_x_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_vector_source_x_0_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_vector_source_x_0_0_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_additive_scrambler_bb_0_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', satellites_varlen_packet_tagger_1, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_print_header_0, in]
- [satellites_varlen_packet_tagger_1, '0', blocks_tag_debug_0_0_0, '0']
- [satellites_varlen_packet_tagger_1, '0', digital_additive_scrambler_bb_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-75-g67e88516
