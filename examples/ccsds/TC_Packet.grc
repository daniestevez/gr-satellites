options:
  parameters:
    generate_options: no_gui
    id: tc_packet
    output_language: python
    run_options: run
  states: {}

blocks:
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '4'
    mask: '0xFF'
    maxsize: '8'
    minsize: '8'
  states: {}
- name: satellites_telecommand_parser_0
  id: satellites_telecommand_parser
  parameters: {}
  states: {}
- name: satellites_telecommand_primaryheader_adder_0
  id: satellites_telecommand_primaryheader_adder
  parameters:
    bypass: '0'
    control: '0'
    spacecraft_id: '0'
    virtual_channel_id: '0'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [pdu_random_pdu_0, pdus, satellites_telecommand_primaryheader_adder_0, in]
- [satellites_telecommand_primaryheader_adder_0, out, satellites_telecommand_parser_0, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-75-g67e88516
