options:
  parameters:
    generate_options: no_gui
    id: tm_packet
    output_language: python
    run_options: run
  states: {}

blocks:
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '4'
    mask: '0xFF'
    maxsize: '4'
    minsize: '4'
  states: {}
- name: satellites_ccsds_telemetry_parser_0
  id: satellites_ccsds_telemetry_parser
  parameters: {}
  states: {}
- name: satellites_telemetry_primaryheader_adder_0
  id: satellites_telemetry_primaryheader_adder
  parameters:
    coding: '1'
    master_channel_frame_count: '1'
    ocf_flag: '0'
    packet_order_flag: '1'
    segment_length_id: '0'
    size: '10'
    spacecraft_id: '25'
    synch_flag: '1'
    transfer_frame_secondary_header_flag: '1'
    virtual_channel_frame_count: '1'
    virtual_channel_id: '2'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [pdu_random_pdu_0, pdus, satellites_telemetry_primaryheader_adder_0, in]
- [satellites_telemetry_primaryheader_adder_0, out, satellites_ccsds_telemetry_parser_0, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-75-g67e88516
