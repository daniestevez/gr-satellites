options:
  parameters:
    generate_options: no_gui
    id: space_packet_no_timestamp
    output_language: python
  states: {}

blocks:
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '4'
    mask: '0xFF'
    maxsize: '4'
    minsize: '4'
  states: {}
- name: satellites_space_packet_parser_0
  id: satellites_space_packet_parser
  parameters:
    id_time: '0'
    time_header: '1'
  states: {}
- name: satellites_space_packet_primaryheader_adder_0
  id: satellites_space_packet_primaryheader_adder
  parameters:
    AP_ID: '0'
    packet_type: '0'
    secondary_header_flag: '1'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [pdu_random_pdu_0, pdus, satellites_space_packet_primaryheader_adder_0, in]
- [satellites_space_packet_primaryheader_adder_0, out, satellites_space_packet_parser_0, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-75-g67e88516
