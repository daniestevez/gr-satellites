options:
  parameters:
    generate_options: no_gui
    id: space_packet_timestamp
    output_language: python
    run_options: run
  states: {}

blocks:
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '4'
    mask: '0xFF'
    maxsize: '4'
    minsize: '4'
  states: {}
- name: satellites_space_packet_parser_0
  id: satellites_space_packet_parser
  parameters:
    id_time: variable_time_format_parameters_0
    pfield: '0'
    time_format: '0'
    time_header: '0'
  states: {}
- name: satellites_space_packet_primaryheader_adder_0
  id: satellites_space_packet_primaryheader_adder
  parameters:
    AP_ID: '0'
    packet_type: '0'
    secondary_header_flag: '1'
  states: {}
- name: satellites_space_packet_time_stamp_adder_0
  id: satellites_space_packet_time_stamp_adder
  parameters:
    id_time: variable_time_format_parameters_0
    manual_automatic: '1'
    pfield: '0'
    pfield_extension: '0'
    time_code_identification_cuc: '1'
    time_format: '0'
  states: {}
- name: variable_time_format_parameters_0
  id: variable_time_format_parameters
  parameters:
    additional_basic_time: '0'
    additional_fractional_time: '0'
    basic_time: '3'
    frac_time: '0'
    time_format_general: '0'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [pdu_random_pdu_0, pdus, satellites_space_packet_time_stamp_adder_0, in]
- [satellites_space_packet_primaryheader_adder_0, out, satellites_space_packet_parser_0, in]
- [satellites_space_packet_time_stamp_adder_0, out, satellites_space_packet_primaryheader_adder_0, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-75-g67e88516
