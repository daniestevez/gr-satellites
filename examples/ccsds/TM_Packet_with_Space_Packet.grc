options:
  parameters:
    generate_options: no_gui
    id: tm_packet_with_space_packet
    output_language: python
    run_options: run
  states: {}

blocks:
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '2'
    minsize: '2'
  states: {}
- name: satellites_ccsds_telemetry_parser_0
  id: satellites_ccsds_telemetry_parser
  parameters: {}
  states: {}
- name: satellites_space_packet_parser_0
  id: satellites_space_packet_parser
  parameters:
    time_header: '1'
  states: {}
- name: satellites_space_packet_primaryheader_adder_0
  id: satellites_space_packet_primaryheader_adder
  parameters:
    AP_ID: '3'
    packet_type: '0'
    secondary_header_flag: '1'
  states: {}
- name: satellites_telemetry_packet_reconstruction_0
  id: satellites_telemetry_packet_reconstruction
  parameters: {}
  states: {}
- name: satellites_telemetry_primaryheader_adder_0
  id: satellites_telemetry_primaryheader_adder
  parameters:
    coding: '1'
    master_channel_frame_count: '0'
    ocf_flag: '0'
    packet_order_flag: '1'
    segment_length_id: '0'
    size: '4'
    spacecraft_id: '0'
    synch_flag: '1'
    transfer_frame_secondary_header_flag: '1'
    virtual_channel_frame_count: '0'
    virtual_channel_id: '0'
  states: {}
- name: tm_frames_sink
  id: virtual_sink
  parameters:
    stream_id: tm_frames
  states: {}
- name: tm_frames_source
  id: virtual_source
  parameters:
    stream_id: tm_frames
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [pdu_random_pdu_0, pdus, satellites_space_packet_primaryheader_adder_0, in]
- [satellites_ccsds_telemetry_parser_0, out, satellites_telemetry_packet_reconstruction_0, in]
- [satellites_space_packet_primaryheader_adder_0, out, satellites_telemetry_primaryheader_adder_0, in]
- [satellites_telemetry_packet_reconstruction_0, out, satellites_space_packet_parser_0, in]
- [satellites_telemetry_primaryheader_adder_0, out, tm_frames_sink, '0']
- [tm_frames_source, '0', satellites_ccsds_telemetry_parser_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
