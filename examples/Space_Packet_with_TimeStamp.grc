<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>space_packet_timestamp</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable_time_format_parameters</key>
<param><key>id</key><value>variable_time_format_parameters_0</value></param>
<param><key>ascii_dec</key><value>ascii_dec</value></param>
<param><key>add_z</key><value>add_z</value></param>
<param><key>additional_basic_time_num_octets_cuc</key><value>additional_basic_time_num_octets_cuc</value></param>
<param><key>basic_time_num_octets_cuc</key><value>basic_time_num_octets_cuc</value></param>
<param><key>calendar_variation</key><value>calendar_variation</value></param>
<param><key>additional_fractional_time_num_octets_cuc</key><value>additional_fractional_time_num_octets_cuc</value></param>
<param><key>fractional_time_num_octets_cuc</key><value>fractional_time_num_octets_cuc</value></param>
<param><key>len_of_day</key><value>len_of_day</value></param>
<param><key>len_of_submilsecs</key><value>len_of_submilsecs</value></param>
<param><key>num_of_subsecs</key><value>num_of_subsecs</value></param>
<param><key>time_format_general</key><value>0</value></param>
<param><key>additional_basic_time</key><value>0</value></param>
<param><key>additional_fractional_time</key><value>0</value></param>
<param><key>basic_time</key><value>3</value></param>
<param><key>frac_time</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>4</value></param>
<param><key>maxsize</key><value>4</value></param>
<param><key>minsize</key><value>4</value></param>
</block>
<block>
<key>satellites_space_packet_parser</key>
<param><key>id</key><value>satellites_space_packet_parser_0</value></param>
<param><key>pfield</key><value>0</value></param>
<param><key>id_time</key><value>variable_time_format_parameters_0</value></param>
<param><key>time_format</key><value>0</value></param>
<param><key>time_header</key><value>0</value></param>
</block>
<block>
<key>satellites_space_packet_primaryheader_adder</key>
<param><key>id</key><value>satellites_space_packet_primaryheader_adder_0</value></param>
<param><key>AP_ID</key><value>0</value></param>
<param><key>packet_type</key><value>0</value></param>
<param><key>secondary_header_flag</key><value>1</value></param>
</block>
<block>
<key>satellites_space_packet_time_stamp_adder</key>
<param><key>id</key><value>satellites_space_packet_time_stamp_adder_0</value></param>
<param><key>manual_automatic</key><value>1</value></param>
<param><key>pfield_extension</key><value>0</value></param>
<param><key>pfield</key><value>0</value></param>
<param><key>time_code_identification_cuc</key><value>1</value></param>
<param><key>id_time</key><value>variable_time_format_parameters_0</value></param>
<param><key>time_format</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>satellites_space_packet_time_stamp_adder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_space_packet_primaryheader_adder_0</source_block_id><sink_block_id>satellites_space_packet_parser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_space_packet_time_stamp_adder_0</source_block_id><sink_block_id>satellites_space_packet_primaryheader_adder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
