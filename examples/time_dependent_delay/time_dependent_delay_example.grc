options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: time_dependent_delay_example
    output_language: python
    title: Time-dependent Delay example
  states: {}

blocks:
- name: dec
  id: variable
  parameters:
    value: '256'
  states: {}
- name: filter_taps
  id: variable
  parameters:
    value: np.array(pm_remez.remez(num_filters * taps_per_filter, [0, passband_end, stopband_start, 0.5], [1, 0], weight=[1, (stopband_weight, stopband_weight * 0.5 / stopband_start)]).impulse_response) * num_filters
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: nint
  id: variable
  parameters:
    value: round(0.1 * samp_rate / nfft)
  states: {}
- name: num_filters
  id: variable
  parameters:
    value: '32'
  states: {}
- name: passband_end
  id: variable
  parameters:
    value: 0.5 * (1 - transition_bandwidth) / num_filters
  states: {}
- name: pulse_end_tag
  id: variable_tag_object
  parameters:
    key: pmt.intern("pulse_end")
    offset: pulse_length - 1
    src: pmt.intern("src")
    value: pmt.PMT_NIL
  states: {}
- name: pulse_length
  id: variable
  parameters:
    value: '100'
  states: {}
- name: pulse_period
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: pulse_start_tag
  id: variable_tag_object
  parameters:
    key: pmt.intern("pulse_start")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.PMT_NIL
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: stopband_start
  id: variable
  parameters:
    value: 0.5 * (1 + transition_bandwidth) / num_filters
  states: {}
- name: stopband_weight
  id: variable
  parameters:
    value: '100'
  states: {}
- name: taps_per_filter
  id: variable
  parameters:
    value: '18'
  states: {}
- name: transition_bandwidth
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 3.45678e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    vlen: nfft
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '10'
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: nint
    type: complex
    vlen: nfft
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: nfft
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '10'
    type: float
    vlen: nfft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[pulse_start_tag, pulse_end_tag]'
    type: complex
    vector: '[1] * pulse_length + [0] * (pulse_period - pulse_length)'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pm_remez
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.5*samp_rate/dec
    decim: dec
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.1*samp_rate/dec
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 1,0
    label1: Delayed
    label2: Original
    name: Spectrum of CW carrier
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / dec
    fc: '0'
    fftsize: '4096'
    gui_hint: 1,1
    label1: Delayed
    name: Spectrum of delayed CW carrier (relative to its carrier frequency)
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1
    label1: Delayed (real)
    label2: Delayed (imag)
    label3: Original (real)
    label4: Original (imag)
    name: Time-domain pulses with tags
    nconnections: '2'
    size: 2 * pulse_period
    srate: samp_rate
    tr_delay: '0.0'
    type: complex
    ymax: '1.2'
    ymin: '-0.1'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: 0,0
    vlen: nfft
    x_axis_label: '"Frequency (MHz)"'
    x_start: '-samp_rate / 2 * 1e-6'
    x_step: samp_rate / nfft * 1e-6
    y_axis_label: '"Cross-correlation phase"'
    ymax: np.pi
    ymin: '-np.pi'
  states: {}
- name: satellites_time_dependent_delay_0
  id: satellites_time_dependent_delay
  parameters:
    file: delay_file.txt
    num_filters: '32'
    samp_rate: samp_rate
    t0: '0'
    taps: filter_taps
  states: {}
- name: satellites_time_dependent_delay_0_0
  id: satellites_time_dependent_delay
  parameters:
    file: delay_file.txt
    num_filters: '32'
    samp_rate: samp_rate
    t0: '0'
    taps: filter_taps
  states: {}
- name: satellites_time_dependent_delay_0_1
  id: satellites_time_dependent_delay
  parameters:
    file: delay_file.txt
    num_filters: '32'
    samp_rate: samp_rate
    t0: '0'
    taps: filter_taps
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_delay_0, '0']
- [analog_noise_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle2_0_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_repeat_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_integrate_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', low_pass_filter_0, '0']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle2_0, '0', satellites_time_dependent_delay_0, '0']
- [blocks_throttle2_0_0, '0', blocks_multiply_conjugate_cc_1, '1']
- [blocks_throttle2_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_throttle2_0_0, '0', satellites_time_dependent_delay_0_0, '0']
- [blocks_throttle2_0_1, '0', satellites_time_dependent_delay_0_1, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0_1, '0']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [satellites_time_dependent_delay_0, '0', blocks_stream_to_vector_0, '0']
- [satellites_time_dependent_delay_0_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [satellites_time_dependent_delay_0_0, '0', qtgui_freq_sink_x_0, '0']
- [satellites_time_dependent_delay_0_1, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
