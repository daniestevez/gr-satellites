options:
  parameters:
    author: Daniel Estevez
    category: '[Satellites]/Scrambling'
    description: PN9 scrambler
    generate_options: hb
    id: pn9_scrambler
    output_language: python
    title: PN9 scrambler
  states: {}

blocks:
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: digital_additive_scrambler_bb_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '8'
    mask: '0x21'
    reset_tag_key: '"packet_len"'
    seed: '0x1FF'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', digital_additive_scrambler_bb_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, pad_sink_0, in]
- [digital_additive_scrambler_bb_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [pad_source_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
