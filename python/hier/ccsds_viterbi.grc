options:
  parameters:
    author: Daniel Estevez
    category: '[Satellites]/FEC'
    description: Viterbi27 decoder with convention (POLYB, ~POLYA) (output is unpacked)
    generate_options: hb
    id: ccsds_viterbi
    output_language: python
    title: CCSDS/NASA-GSFC Viterbi decoder
  states: {}

blocks:
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: '80'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79, -109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_cc
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [fec_extended_decoder_0_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', fec_extended_decoder_0_0, '0']

metadata:
  file_format: 1
