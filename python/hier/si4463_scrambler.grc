options:
  parameters:
    author: Daniel Estevez
    category: '[Satellites]/Scrambling'
    description: SI4463 scrambler
    generate_options: hb
    id: si4463_scrambler
    output_language: python
    title: SI4463 scrambler
  states: {}

blocks:
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1.0/8
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: digital_additive_scrambler_bb_0_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '8'
    mask: '0x21'
    reset_tag_key: '"packet_len"'
    seed: '0x1e1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', digital_additive_scrambler_bb_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [blocks_tagged_stream_to_pdu_0_0, pdus, pad_sink_0, in]
- [digital_additive_scrambler_bb_0_0, '0', blocks_pack_k_bits_bb_0, '0']
- [pad_source_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
