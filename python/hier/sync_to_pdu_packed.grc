options:
  parameters:
    author: Daniel Estevez
    category: '[Satellites]/Packet Operators'
    description: Finds syncword and creates a PDU of fixed size and packed bytes
    generate_options: hb
    id: sync_to_pdu_packed
    output_language: python
    title: Sync and create packed PDU
  states: {}

blocks:
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1/8.0
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_bb_0_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: sync
    tagname: syncword
    threshold: threshold
    type: byte
  states: {}
- name: packlen
  id: parameter
  parameters:
    label: Packet length (bytes)
    type: intx
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: satellites_fixedlen_tagger_0_0_0
  id: satellites_fixedlen_tagger
  parameters:
    packet_len: packlen*8
    packetlen_tag: packet_len
    stream_type: byte
    syncword_tag: syncword
  states: {}
- name: sync
  id: parameter
  parameters:
    label: Syncword
    value: '"00011010110011111111110000011101"'
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Syncword threshold
    type: intx
    value: '4'
  states: {}

connections:
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_tagged_stream_to_pdu_0_0_0, pdus, pad_sink_0, in]
- [blocks_unpacked_to_packed_xx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_correlate_access_code_tag_bb_0_0_0, '0', satellites_fixedlen_tagger_0_0_0, '0']
- [pad_source_0, '0', digital_correlate_access_code_tag_bb_0_0_0, '0']
- [satellites_fixedlen_tagger_0_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']

metadata:
  file_format: 1
