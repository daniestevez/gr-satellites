<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>varlen_packet_test</value></param>
<param><key>description</key><value>Test out the framing and tagging variable length packet blocks</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>max_nouts</key><value>1000</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>binary</value></param>
<param><key>value</key><value>"".join([bin(int(hex_bits[2*i:(2*i+2)], 16))[2:].zfill(8) for i in range(len(hex_bits)/2)])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hex_bits</value></param>
<param><key>value</key><value>hex_space.replace(' ','')</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hex_space</value></param>
<param><key>value</key><value>'94 50 73 00 00 01 02 03 04 05 06 07 08 09 0a 0b 0c 0d 0e 0f 10 11 12 13 14 15 16 17 18 19 1a 1b 1c 1d 1e 1f 20 21 22 23 24 25 26 27 28 29 2a 2b 2c 2d 2e 2f 30 31 32 33 34 35 36 37 38 39 3a 3b 3c 3d 3e 3f 40 41 42 43 44 45 46 47 48 49 4a 4b 4c 4d 4e 4f 50 51 52 53 54 55 56 57 58 59 5a 5b 5c 5d 5e 5f 60 61 62 63'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_packets</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet</value></param>
<param><key>value</key><value>[int(x) for x in list(binary)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>(1,1,1,1,1,1,1,1,0,0,0,0,0,0,0,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word</value></param>
<param><key>value</key><value>(1,1,0,1,0,0,1,1,0,0,0,0,1,0,1,1,0,1,0,1,0,0,0,1,1,1,0,1,1,1,1,0)</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>len(packet)*num_packets</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(packet), packet))</value></param>
<param><key>period</key><value>100</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>T0</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>T2</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>T1</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>c</key><value>1/8.0</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0_0_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_bb</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0_0</value></param>
<param><key>access_code</key><value>"".join([str(x) for x in sync_word])</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>pi_0</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>satellites_print_header</key>
<param><key>id</key><value>satellites_print_header_0_0</value></param>
</block>
<block>
<key>satellites_swap_header</key>
<param><key>id</key><value>satellites_swap_header_0_0</value></param>
</block>
<block>
<key>satellites_varlen_packet_framer</key>
<param><key>id</key><value>satellites_varlen_packet_framer_1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>use_golay</key><value>True</value></param>
<param><key>length_field_size</key><value>24</value></param>
<param><key>packetlen_tag</key><value>packet_len</value></param>
<param><key>sync_word</key><value>preamble+sync_word</value></param>
</block>
<block>
<key>satellites_varlen_packet_tagger</key>
<param><key>id</key><value>satellites_varlen_packet_tagger_0_0</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>use_golay</key><value>True</value></param>
<param><key>mtu</key><value>255*8</value></param>
<param><key>length_field_size</key><value>12</value></param>
<param><key>packetlen_tag</key><value>packet_len</value></param>
<param><key>syncword_tag</key><value>syncword</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>satellites_varlen_packet_framer_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>strobe</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0_0</source_block_id><sink_block_id>satellites_swap_header_0_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0_0_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0_0</source_block_id><sink_block_id>satellites_varlen_packet_tagger_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_swap_header_0_0</source_block_id><sink_block_id>satellites_print_header_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_varlen_packet_framer_1</source_block_id><sink_block_id>blocks_tag_debug_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_varlen_packet_framer_1</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_varlen_packet_tagger_0_0</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_varlen_packet_tagger_0_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
