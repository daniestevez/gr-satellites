<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>reed_solomon</value></param>
<param><key>author</key><value>Daniel Estevez</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Test Reed-Solomon encoding and decoding</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>1</value></param>
<param><key>maxsize</key><value>223</value></param>
<param><key>minsize</key><value>1</value></param>
</block>
<block>
<key>satellites_decode_rs</key>
<param><key>id</key><value>satellites_decode_rs_0</value></param>
<param><key>basis</key><value>0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>satellites_encode_rs</key>
<param><key>id</key><value>satellites_encode_rs_0</value></param>
<param><key>basis</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>satellites_encode_rs_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>satellites_encode_rs_0</source_block_id><sink_block_id>satellites_decode_rs_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
