<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>at03</value></param>
<param><key>author</key><value>Daniel Estevez</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>QB50 AT03 PEGASUS decoder</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>QB50 AT03 PEGASUS decoder</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>access_code</value></param>
<param><key>value</key><value>"0010110111010100"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>32767.0</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>ip</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>port</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>callsign</value></param>
<param><key>label</key><value>your callsign</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>5.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>invert</value></param>
<param><key>label</key><value>invert the waveform (-1 to invert)</value></param>
<param><key>short_id</key><value>i</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ip</value></param>
<param><key>label</key><value>UDP listen IP</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>::</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>latitude</value></param>
<param><key>label</key><value>latitude (format 00.000 or -00.000)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>longitude</value></param>
<param><key>label</key><value>longitude (format 00.000 or -00.000)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>5000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>invert*10</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>CRC16_ARC</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>UDP port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7355</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>recstart</value></param>
<param><key>label</key><value>start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>satellites_check_tt64_crc</key>
<param><key>id</key><value>satellites_check_tt64_crc_0</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>satellites_print_timestamp</key>
<param><key>id</key><value>satellites_print_timestamp_0</value></param>
<param><key>fmt</key><value>%Y-%m-%d %H:%M:%S</value></param>
</block>
<block>
<key>satellites_rscode_decoder</key>
<param><key>id</key><value>satellites_rscode_decoder_0</value></param>
<param><key>npar</key><value>16</value></param>
</block>
<block>
<key>satellites_submit</key>
<param><key>id</key><value>satellites_submit_0</value></param>
<param><key>latitude</key><value>latitude</value></param>
<param><key>longitude</key><value>longitude</value></param>
<param><key>noradID</key><value>42784</value></param>
<param><key>source</key><value>callsign</value></param>
<param><key>tstamp</key><value>recstart</value></param>
<param><key>url</key><value>http://tlm.pe0sat.nl/tlmdb/frame_db.php</value></param>
</block>
<block>
<key>satellites_submit</key>
<param><key>id</key><value>satellites_submit_0_0</value></param>
<param><key>comment</key><value>Telemetry submit block requested by the Pegasus team</value></param>
<param><key>latitude</key><value>latitude</value></param>
<param><key>longitude</key><value>longitude</value></param>
<param><key>noradID</key><value>42784</value></param>
<param><key>source</key><value>callsign</value></param>
<param><key>tstamp</key><value>recstart</value></param>
<param><key>url</key><value>http://spacedatacenter.at/sids/report_frame.php</value></param>
</block>
<block>
<key>sync_to_pdu_packed</key>
<param><key>id</key><value>sync_to_pdu_packed_0</value></param>
<param><key>packlen</key><value>64</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>sync</key><value>access_code</value></param>
</block>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>sync_to_pdu_packed_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_check_tt64_crc_0</source_block_id><sink_block_id>satellites_print_timestamp_0</sink_block_id><source_key>ok</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_print_timestamp_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>satellites_print_timestamp_0</source_block_id><sink_block_id>satellites_submit_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_rscode_decoder_0</source_block_id><sink_block_id>satellites_check_tt64_crc_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sync_to_pdu_packed_0</source_block_id><sink_block_id>satellites_rscode_decoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sync_to_pdu_packed_0</source_block_id><sink_block_id>satellites_submit_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
