options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: QB50 AT03 PEGASUS decoder
    generate_options: no_gui
    id: at03
    output_language: python
    run_options: run
    title: QB50 AT03 PEGASUS decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"0010110111010100"'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767.0'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: ip
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: '5.0'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: invert
  id: parameter
  parameters:
    label: invert the waveform (-1 to invert)
    short_id: i
    type: intx
    value: '1'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: '::'
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: invert*10
    samp_rate: '48000'
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: CRC16_ARC
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: recstart
  id: parameter
  parameters:
    label: start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)
    type: str
    value: ''
  states: {}
- name: satellites_check_tt64_crc_0
  id: satellites_check_tt64_crc
  parameters:
    verbose: 'False'
  states: {}
- name: satellites_decode_rs_general_0
  id: satellites_decode_rs_general
  parameters:
    fcr: '1'
    gfpoly: '0x11d'
    nroots: '16'
    prim: '1'
    verbose: 'True'
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '42784'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: satellites_submit_0_0
  id: satellites_submit
  parameters:
    comment: Telemetry submit block requested by the Pegasus team
    latitude: latitude
    longitude: longitude
    noradID: '42784'
    source: callsign
    tstamp: recstart
    url: https://spacedatacenter.at/sids/report_frame.php
  states: {}
- name: sync_to_pdu_packed_0
  id: sync_to_pdu_packed
  parameters:
    packlen: '64'
    sync: access_code
    threshold: threshold
  states: {}

connections:
- [blocks_short_to_float_0, '0', low_pass_filter_0, '0']
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', sync_to_pdu_packed_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [satellites_check_tt64_crc_0, ok, satellites_print_timestamp_0, in]
- [satellites_decode_rs_general_0, out, satellites_check_tt64_crc_0, in]
- [satellites_print_timestamp_0, out, blocks_message_debug_0, print_pdu]
- [satellites_print_timestamp_0, out, satellites_submit_0, in]
- [sync_to_pdu_packed_0, out, satellites_decode_rs_general_0, in]
- [sync_to_pdu_packed_0, out, satellites_submit_0_0, in]

metadata:
  file_format: 1
