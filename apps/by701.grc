options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: BY70-1 decoder
    generate_options: no_gui
    id: by701
    output_language: python
    run_options: run
    title: BY70-1 decoder
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: nfilts_0
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, 11*sps*nfilts)
  states: {}
- name: rrc_taps_0
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(samp_per_sym), 0.35, 11*samp_per_sym*nfilts)
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '3'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: variable_constellation_0_0
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: bfo
  id: parameter
  parameters:
    label: carrier frequency of the BPSK signal
    type: eng_float
    value: '12000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '60061'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: ip
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: ccsds_descrambler_0
  id: ccsds_descrambler
  parameters: {}
  states: {}
- name: ccsds_viterbi_0
  id: ccsds_viterbi
  parameters: {}
  states: {}
- name: ccsds_viterbi_0_0
  id: ccsds_viterbi
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.1'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '100'
    rolloff: '0.350'
    samps_per_sym: sps
    type: cc
    w: '0.01'
  states: {}
- name: digital_lms_dd_equalizer_cc_0_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: variable_constellation_0
    mu: '0.05'
    num_taps: '2'
    sps: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.05'
    max_dev: '0.05'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: bfo
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 10000, 1000)
    type: fcf
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: '::'
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: lilacsat_kiss_encode_pdu_0
  id: lilacsat_kiss_encode_pdu
  parameters:
    const_length: '-1'
  states: {state: disabled}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Enable to use lilacsat_proxy.py to submit telemetry
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: recstart
  id: parameter
  parameters:
    label: start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)
    type: str
    value: ''
  states: {}
- name: rms_agc_0
  id: rms_agc
  parameters:
    alpha: '1e-2'
    reference: '0.5'
  states: {}
- name: satellites_by701_camera_telemetry_parser_0
  id: satellites_by701_camera_telemetry_parser
  parameters: {}
  states: {}
- name: satellites_by701_image_decoder_0
  id: satellites_by701_image_decoder
  parameters:
    display: 'True'
    fullscreen: 'True'
    path: /tmp
  states: {}
- name: satellites_by701_telemetry_parser_0
  id: satellites_by701_telemetry_parser
  parameters: {}
  states: {state: disabled}
- name: satellites_decode_rs_0
  id: satellites_decode_rs
  parameters:
    basis: '0'
    verbose: 'True'
  states: {}
- name: satellites_kiss_to_pdu_0
  id: satellites_kiss_to_pdu
  parameters:
    control_byte: 'False'
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '41909'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: satellites_swap_header_0
  id: satellites_swap_header
  parameters: {}
  states: {}
- name: sync_to_pdu_0
  id: sync_to_pdu
  parameters:
    packlen: (114+32)*8
    sync: '"00011010110011111111110000011101"'
    threshold: threshold
  states: {}
- name: sync_to_pdu_0_0
  id: sync_to_pdu
  parameters:
    packlen: (114+32)*8
    sync: '"00011010110011111111110000011101"'
    threshold: threshold
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_real_0, '0', ccsds_viterbi_0, '0']
- [blocks_delay_0, '0', ccsds_viterbi_0_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', satellites_kiss_to_pdu_0, '0']
- [blocks_short_to_float_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [ccsds_descrambler_0, out, satellites_decode_rs_0, in]
- [ccsds_viterbi_0, '0', digital_diff_decoder_bb_0, '0']
- [ccsds_viterbi_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_lms_dd_equalizer_cc_0_0, '0']
- [digital_diff_decoder_bb_0, '0', sync_to_pdu_0, '0']
- [digital_diff_decoder_bb_0_0, '0', sync_to_pdu_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_lms_dd_equalizer_cc_0_0, '0', blocks_complex_to_real_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rms_agc_0, '0']
- [lilacsat_kiss_encode_pdu_0, out, blocks_socket_pdu_0_0, pdus]
- [rms_agc_0, '0', digital_fll_band_edge_cc_0, '0']
- [satellites_decode_rs_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_kiss_to_pdu_0, out, lilacsat_kiss_encode_pdu_0, in]
- [satellites_kiss_to_pdu_0, out, satellites_print_timestamp_0, in]
- [satellites_kiss_to_pdu_0, out, satellites_submit_0, in]
- [satellites_print_timestamp_0, out, satellites_swap_header_0, in]
- [satellites_swap_header_0, out, satellites_by701_camera_telemetry_parser_0, in]
- [satellites_swap_header_0, out, satellites_by701_image_decoder_0, in]
- [satellites_swap_header_0, out, satellites_by701_telemetry_parser_0, in]
- [sync_to_pdu_0, out, ccsds_descrambler_0, in]
- [sync_to_pdu_0_0, out, ccsds_descrambler_0, in]

metadata:
  file_format: 1
