options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: Swiatowid 9k6 decoder
    generate_options: no_gui
    id: swiatowid
    output_language: python
    run_options: run
    title: Swiatowid 9k6 decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''01011011010110111101110111011101'''
  states: {}
- name: gain_mu
  id: variable
  parameters:
    value: 0.175*3*0.5
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: invert*10
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767.0'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: ip
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: gain_mu
    gain_omega: 0.25*gain_mu*gain_mu
    mu: '0.5'
    omega: '5'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: invert
  id: parameter
  parameters:
    label: invert the waveform (-1 to invert)
    short_id: i
    type: intx
    value: '1'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: '::'
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 9k6
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: recstart
  id: parameter
  parameters:
    label: start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)
    type: str
    value: ''
  states: {}
- name: satellites_decode_rs_general_0
  id: satellites_decode_rs_general
  parameters:
    fcr: '0'
    gfpoly: '0x11d'
    nroots: '10'
    prim: '1'
    verbose: 'False'
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_reflect_bytes_0
  id: satellites_reflect_bytes
  parameters: {}
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '44426'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {state: disabled}
- name: satellites_swiatowid_image_decoder_0
  id: satellites_swiatowid_image_decoder
  parameters:
    display: 'True'
    fullscreen: 'True'
    path: /tmp/
  states: {}
- name: satellites_swiatowid_packet_crop_0
  id: satellites_swiatowid_packet_crop
  parameters: {}
  states: {}
- name: satellites_swiatowid_packet_split_0
  id: satellites_swiatowid_packet_split
  parameters: {}
  states: {}
- name: sync_to_pdu_packed_0_0
  id: sync_to_pdu_packed
  parameters:
    packlen: '8200'
    sync: access_code
    threshold: threshold
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [digital_binary_slicer_fb_0_0, '0', sync_to_pdu_packed_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [satellites_decode_rs_general_0, out, satellites_swiatowid_image_decoder_0, in]
- [satellites_print_timestamp_0, out, satellites_swiatowid_packet_split_0, in]
- [satellites_reflect_bytes_0, out, satellites_swiatowid_packet_crop_0, in]
- [satellites_swiatowid_packet_crop_0, out, satellites_print_timestamp_0, in]
- [satellites_swiatowid_packet_split_0, out, satellites_decode_rs_general_0, in]
- [sync_to_pdu_packed_0_0, out, satellites_reflect_bytes_0, in]

metadata:
  file_format: 1
