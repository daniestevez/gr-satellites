options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: Astrocast decoder
    generate_options: no_gui
    id: astrocast
    output_language: python
    run_options: run
    title: Astrocast decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''0111010111111010110000011010001101011000110100000110010001110110'''
  states: {}
- name: gain_mu
  id: variable
  parameters:
    value: 0.175*5
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '8'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: invert*10
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767.0'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'True'
    type: TCP_SERVER
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: ip
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: gain_mu
    gain_omega: 0.25*gain_mu*gain_mu
    mu: '0.5'
    omega: '8'
    omega_relative_limit: '0.05'
    type: float
  states: {}
- name: invert
  id: parameter
  parameters:
    label: invert the waveform (-1 to invert)
    short_id: i
    type: intx
    value: '1'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: '::'
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1000'
    decim: '5'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '600'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 1k2
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: recstart
  id: parameter
  parameters:
    label: start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)
    type: str
    value: ''
  states: {}
- name: satellites_check_astrocast_crc_0
  id: satellites_check_astrocast_crc
  parameters:
    verbose: 'False'
  states: {}
- name: satellites_decode_rs_0
  id: satellites_decode_rs
  parameters:
    basis: '1'
    verbose: 'True'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_pdu_to_kiss_0
  id: satellites_pdu_to_kiss
  parameters: {}
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_reflect_bytes_0
  id: satellites_reflect_bytes
  parameters: {}
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '43798'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: sync_to_pdu_packed_0
  id: sync_to_pdu_packed
  parameters:
    packlen: '255'
    sync: access_code
    threshold: threshold
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [satellites_check_astrocast_crc_0, ok, satellites_print_timestamp_0, in]
- [satellites_decode_rs_0, out, satellites_check_astrocast_crc_0, in]
- [satellites_nrzi_decode_0, '0', sync_to_pdu_packed_0, '0']
- [satellites_pdu_to_kiss_0, out, blocks_socket_pdu_0, pdus]
- [satellites_print_timestamp_0, out, blocks_message_debug_0, print_pdu]
- [satellites_print_timestamp_0, out, satellites_pdu_to_kiss_0, in]
- [satellites_print_timestamp_0, out, satellites_submit_0, in]
- [satellites_reflect_bytes_0, out, satellites_decode_rs_0, in]
- [sync_to_pdu_packed_0, out, satellites_reflect_bytes_0, in]

metadata:
  file_format: 1
