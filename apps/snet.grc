options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: S-NET decoder
    generate_options: no_gui
    id: snet
    output_language: python
    run_options: run
    title: S-NET decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"00000100110011110101111111001000"'
  states: {}
- name: lowpass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '1200'
    gain: '1.0'
    samp_rate: '48000'
    width: '400'
    win: firdes.WIN_HAMMING
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '-5'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767.0'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: ip
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.1*0.25*0.175*0.175
    mu: '0.5'
    omega: '40'
    omega_relative_limit: '0.5'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (1200+1800)/2
    decim: '1'
    samp_rate: '48000'
    taps: lowpass_taps
    type: fcf
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: '::'
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '800'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '400'
    win: firdes.WIN_HAMMING
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: recstart
  id: parameter
  parameters:
    label: start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)
    type: str
    value: ''
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_snet_classifier_0
  id: satellites_snet_classifier
  parameters: {}
  states: {}
- name: satellites_snet_deframer_0
  id: satellites_snet_deframer
  parameters:
    verbose: 'False'
  states: {}
- name: satellites_snet_telemetry_parser_0
  id: satellites_snet_telemetry_parser
  parameters: {}
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '42723'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {state: disabled}
- name: satellites_submit_0_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '42723'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {state: disabled}
- name: satellites_submit_0_1
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '42723'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {state: disabled}
- name: satellites_submit_0_2
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '42723'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {state: disabled}
- name: sync_to_pdu_0
  id: sync_to_pdu
  parameters:
    packlen: 8*512
    sync: access_code
    threshold: '0'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [blocks_short_to_float_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', sync_to_pdu_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [satellites_print_timestamp_0, out, satellites_snet_classifier_0, in]
- [satellites_print_timestamp_0, out, satellites_snet_telemetry_parser_0, in]
- [satellites_snet_classifier_0, SNET-A, satellites_submit_0, in]
- [satellites_snet_classifier_0, SNET-B, satellites_submit_0_0, in]
- [satellites_snet_classifier_0, SNET-C, satellites_submit_0_1, in]
- [satellites_snet_classifier_0, SNET-D, satellites_submit_0_2, in]
- [satellites_snet_deframer_0, out, satellites_print_timestamp_0, in]
- [sync_to_pdu_0, out, satellites_snet_deframer_0, in]

metadata:
  file_format: 1
