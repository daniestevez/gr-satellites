<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lilacsat2_rtlsdr</value></param>
<param><key>author</key><value>Daniel Estevez</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>LilacSat-2 decoder for RTL-SDR device</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>LilacSat-2 decoder for RTL-SDR device</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>af_samp_rate</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>doppler_freq</value></param>
<param><key>value</key><value>freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>437.2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>if_samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>30e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_samp_rate</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, 11*sps*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sub_alpha</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sub_nfilts</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sub_rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(sub_nfilts, sub_nfilts, 1.0/float(sub_sps), sub_alpha, 11*sub_sps*sub_nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sub_sps</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>variable_constellation_0</value></param>
<param><key>const_points</key><value>[-1, 1]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0, 1]</value></param>
</block>
<block>
<key>analog_feedforward_agc_cc</key>
<param><key>id</key><value>analog_feedforward_agc_cc_0</value></param>
<param><key>num_samples</key><value>1024</value></param>
<param><key>reference</key><value>2</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>af_samp_rate</value></param>
<param><key>max_dev</key><value>3.5e3</value></param>
<param><key>quad_rate</key><value>if_samp_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>0.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>label</key><value>baseband gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>60061</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_CLIENT"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>callsign</value></param>
<param><key>label</key><value>your callsign</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>ccsds_descrambler</key>
<param><key>id</key><value>ccsds_descrambler_0</value></param>
</block>
<block>
<key>ccsds_descrambler</key>
<param><key>id</key><value>ccsds_descrambler_0_0</value></param>
</block>
<block>
<key>ccsds_descrambler</key>
<param><key>id</key><value>ccsds_descrambler_0_0_0</value></param>
</block>
<block>
<key>ccsds_viterbi</key>
<param><key>id</key><value>ccsds_viterbi_0</value></param>
</block>
<block>
<key>ccsds_viterbi</key>
<param><key>id</key><value>ccsds_viterbi_0_0</value></param>
</block>
<block>
<key>ccsds_viterbi</key>
<param><key>id</key><value>ccsds_viterbi_0_0_0</value></param>
</block>
<block>
<key>ccsds_viterbi</key>
<param><key>id</key><value>ccsds_viterbi_0_1</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>1024</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_1</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>10</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0</value></param>
<param><key>w</key><value>0.4</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_0</value></param>
<param><key>rolloff</key><value>0.350</value></param>
<param><key>w</key><value>0.1</value></param>
<param><key>filter_size</key><value>100</value></param>
<param><key>samps_per_sym</key><value>sps</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>digital_lms_dd_equalizer_cc</key>
<param><key>id</key><value>digital_lms_dd_equalizer_cc_0_0</value></param>
<param><key>cnst</key><value>variable_constellation_0</value></param>
<param><key>mu</key><value>0.3</value></param>
<param><key>num_taps</key><value>2</value></param>
<param><key>sps</key><value>2</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>0.100</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>2</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0_0</value></param>
<param><key>filter_size</key><value>sub_nfilts</value></param>
<param><key>init_phase</key><value>sub_nfilts/2</value></param>
<param><key>loop_bw</key><value>0.0628</value></param>
<param><key>max_dev</key><value>0.01</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sub_sps</value></param>
<param><key>taps</key><value>sub_rrc_taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_corr</value></param>
<param><key>label</key><value>frequency correction (ppm)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>doppler_freq - freq + offset + 25e3</value></param>
<param><key>decim</key><value>int(rf_samp_rate/if_samp_rate)</value></param>
<param><key>samp_rate</key><value>rf_samp_rate</value></param>
<param><key>taps</key><value>filter.firdes.low_pass(1,rf_samp_rate,5000,2000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>center_freq</key><value>doppler_freq - freq + offset</value></param>
<param><key>decim</key><value>int(rf_samp_rate/if_samp_rate)</value></param>
<param><key>samp_rate</key><value>rf_samp_rate</value></param>
<param><key>taps</key><value>filter.firdes.low_pass(1,rf_samp_rate,10000,2000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>gpredict_doppler</key>
<param><key>id</key><value>gpredict_doppler_0</value></param>
<param><key>gpredict_host</key><value>localhost</value></param>
<param><key>gpredict_port</key><value>gpredict_port</value></param>
<param><key>target</key><value>doppler_freq</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gpredict_port</value></param>
<param><key>label</key><value>GPredict port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4532</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>label</key><value>IF gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>satellites_kiss_to_pdu</key>
<param><key>id</key><value>satellites_kiss_to_pdu_0</value></param>
<param><key>control_byte</key><value>False</value></param>
</block>
<block>
<key>satellites_kiss_to_pdu</key>
<param><key>id</key><value>satellites_kiss_to_pdu_0_0</value></param>
<param><key>control_byte</key><value>False</value></param>
</block>
<block>
<key>satellites_kiss_to_pdu</key>
<param><key>id</key><value>satellites_kiss_to_pdu_0_1</value></param>
<param><key>control_byte</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>latitude</value></param>
<param><key>label</key><value>latitude (format 00.000 or -00.000)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>satellites_decode_rs</key>
<param><key>id</key><value>satellites_decode_rs_0</value></param>
<param><key>basis</key><value>0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>satellites_decode_rs</key>
<param><key>id</key><value>satellites_decode_rs_0_0</value></param>
<param><key>basis</key><value>0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>satellites_decode_rs</key>
<param><key>id</key><value>satellites_decode_rs_0_0_0</value></param>
<param><key>basis</key><value>0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>longitude</value></param>
<param><key>label</key><value>longitude (format 00.000 or -00.000)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>200</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>af_samp_rate</value></param>
<param><key>width</key><value>50</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_3_0_0</value></param>
<param><key>cutoff_freq</key><value>8e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>if_samp_rate</value></param>
<param><key>width</key><value>2e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Enable to use lilacsat_proxy.py to submit telemetry</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0</value></param>
<param><key>note</key><value>437.200MHz baseband</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>4k8 GFSK decoder</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0</value></param>
<param><key>note</key><value>9k6 BPSK decoder</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4</value></param>
<param><key>note</key><value>Subaudio decoder</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>corr0</key><value>freq_corr</value></param>
<param><key>freq0</key><value>freq-offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value>rtl</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>rf_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>label</key><value>RF gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>satellites_print_timestamp</key>
<param><key>id</key><value>satellites_print_timestamp_0</value></param>
<param><key>fmt</key><value>%Y-%m-%d %H:%M:%S</value></param>
</block>
<block>
<key>satellites_submit</key>
<param><key>id</key><value>satellites_submit_0</value></param>
<param><key>latitude</key><value>latitude</value></param>
<param><key>longitude</key><value>longitude</value></param>
<param><key>noradID</key><value>40908</value></param>
<param><key>source</key><value>callsign</value></param>
<param><key>url</key><value>http://tlm.pe0sat.nl/tlmdb/frame_db.php</value></param>
</block>
<block>
<key>sync_to_pdu</key>
<param><key>id</key><value>sync_to_pdu_0</value></param>
<param><key>packlen</key><value>(114+32)*8</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>sync</key><value>"00011010110011111111110000011101"</value></param>
</block>
<block>
<key>sync_to_pdu</key>
<param><key>id</key><value>sync_to_pdu_0_0</value></param>
<param><key>packlen</key><value>(114+32)*8</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>sync</key><value>"00011010110011111111110000011101"</value></param>
</block>
<block>
<key>sync_to_pdu</key>
<param><key>id</key><value>sync_to_pdu_0_0_0</value></param>
<param><key>packlen</key><value>(114+32)*8</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>sync</key><value>"00011010110011111111110000011101"</value></param>
</block>
<block>
<key>sync_to_pdu</key>
<param><key>id</key><value>sync_to_pdu_0_1</value></param>
<param><key>packlen</key><value>(114+32)*8</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>sync</key><value>"00011010110011111111110000011101"</value></param>
</block>
<block>
<key>sync_to_pdu</key>
<param><key>id</key><value>sync_to_pdu_0_1_0</value></param>
<param><key>packlen</key><value>(114+32)*8</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>sync</key><value>"00011010110011111111110000011101"</value></param>
</block>
<connection><source_block_id>analog_feedforward_agc_cc_0</source_block_id><sink_block_id>digital_fll_band_edge_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>ccsds_viterbi_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>ccsds_viterbi_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>ccsds_viterbi_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>satellites_kiss_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>satellites_kiss_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1</source_block_id><sink_block_id>satellites_kiss_to_pdu_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_descrambler_0</source_block_id><sink_block_id>satellites_decode_rs_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_descrambler_0_0</source_block_id><sink_block_id>satellites_decode_rs_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_descrambler_0_0_0</source_block_id><sink_block_id>satellites_decode_rs_0_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_viterbi_0</source_block_id><sink_block_id>sync_to_pdu_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_viterbi_0_0</source_block_id><sink_block_id>sync_to_pdu_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_viterbi_0_0_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ccsds_viterbi_0_1</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_1</source_block_id><sink_block_id>sync_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>ccsds_viterbi_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>digital_lms_dd_equalizer_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>sync_to_pdu_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0_0</source_block_id><sink_block_id>sync_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_lms_dd_equalizer_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0_0</source_block_id><sink_block_id>digital_binary_slicer_fb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>analog_feedforward_agc_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>low_pass_filter_3_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_kiss_to_pdu_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>satellites_kiss_to_pdu_0</source_block_id><sink_block_id>satellites_print_timestamp_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_kiss_to_pdu_0</source_block_id><sink_block_id>satellites_submit_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_kiss_to_pdu_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>satellites_kiss_to_pdu_0_0</source_block_id><sink_block_id>satellites_print_timestamp_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_kiss_to_pdu_0_0</source_block_id><sink_block_id>satellites_submit_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_kiss_to_pdu_0_1</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>satellites_kiss_to_pdu_0_1</source_block_id><sink_block_id>satellites_print_timestamp_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_kiss_to_pdu_0_1</source_block_id><sink_block_id>satellites_submit_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_0_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_3_0_0</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_print_timestamp_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>sync_to_pdu_0</source_block_id><sink_block_id>ccsds_descrambler_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sync_to_pdu_0_0</source_block_id><sink_block_id>ccsds_descrambler_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sync_to_pdu_0_0_0</source_block_id><sink_block_id>ccsds_descrambler_0_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sync_to_pdu_0_1</source_block_id><sink_block_id>ccsds_descrambler_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sync_to_pdu_0_1_0</source_block_id><sink_block_id>ccsds_descrambler_0_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
