options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: LilacSat-2 decoder for RTL-SDR device
    generate_options: no_gui
    id: lilacsat2_rtlsdr
    output_language: python
    run_options: run
    title: LilacSat-2 decoder for RTL-SDR device
  states: {}

blocks:
- name: af_samp_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: doppler_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: freq
  id: variable
  parameters:
    value: 437.2e6
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: offset
  id: variable
  parameters:
    value: 30e3
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), alpha, 11*sps*nfilts)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: sub_alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: sub_nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: sub_rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(sub_nfilts, sub_nfilts, 1.0/float(sub_sps), sub_alpha, 11*sub_sps*sub_nfilts)
  states: {}
- name: sub_sps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    dims: '1'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: af_samp_rate
    max_dev: 3.5e3
    quad_rate: if_samp_rate
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '0.5'
  states: {}
- name: bb_gain
  id: parameter
  parameters:
    label: baseband gain
    type: eng_float
    value: '20'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '60061'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: ccsds_descrambler_0
  id: ccsds_descrambler
  parameters: {}
  states: {}
- name: ccsds_descrambler_0_0
  id: ccsds_descrambler
  parameters: {}
  states: {}
- name: ccsds_descrambler_0_0_0
  id: ccsds_descrambler
  parameters: {}
  states: {}
- name: ccsds_viterbi_0
  id: ccsds_viterbi
  parameters: {}
  states: {}
- name: ccsds_viterbi_0_0
  id: ccsds_viterbi
  parameters: {}
  states: {}
- name: ccsds_viterbi_0_0_0
  id: ccsds_viterbi
  parameters: {}
  states: {}
- name: ccsds_viterbi_0_1
  id: ccsds_viterbi
  parameters: {}
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: '10'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.4'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '100'
    rolloff: '0.350'
    samps_per_sym: sps
    type: cc
    w: '0.1'
  states: {}
- name: digital_lms_dd_equalizer_cc_0_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: variable_constellation_0
    mu: '0.3'
    num_taps: '2'
    sps: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.100'
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: sub_nfilts
    init_phase: sub_nfilts/2
    loop_bw: '0.0628'
    max_dev: '0.01'
    osps: '1'
    sps: sub_sps
    taps: sub_rrc_taps
    type: fff
  states: {}
- name: freq_corr
  id: parameter
  parameters:
    label: frequency correction (ppm)
    type: eng_float
    value: '0'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: doppler_freq - freq + offset + 25e3
    decim: int(rf_samp_rate/if_samp_rate)
    samp_rate: rf_samp_rate
    taps: filter.firdes.low_pass(1,rf_samp_rate,5000,2000)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: doppler_freq - freq + offset
    decim: int(rf_samp_rate/if_samp_rate)
    samp_rate: rf_samp_rate
    taps: filter.firdes.low_pass(1,rf_samp_rate,10000,2000)
    type: ccc
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: gpredict_port
    target: doppler_freq
    verbose: 'False'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: GPredict port
    type: intx
    value: '4532'
  states: {}
- name: if_gain
  id: parameter
  parameters:
    label: IF gain
    type: eng_float
    value: '20'
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '1'
    gain: '1'
    samp_rate: af_samp_rate
    type: fir_filter_fff
    width: '50'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_3_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 8e3
    decim: '1'
    gain: '1'
    samp_rate: if_samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Enable to use lilacsat_proxy.py to submit telemetry
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: 437.200MHz baseband
  states: {}
- name: note_2
  id: note
  parameters:
    note: 4k8 GFSK decoder
  states: {}
- name: note_2_0
  id: note
  parameters:
    note: 9k6 BPSK decoder
  states: {}
- name: note_4
  id: note
  parameters:
    note: Subaudio decoder
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl
    bb_gain0: bb_gain
    corr0: freq_corr
    freq0: freq-offset
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: rf_samp_rate
    sync: ''
    type: fc32
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF gain
    type: eng_float
    value: '40'
  states: {}
- name: rms_agc_0
  id: rms_agc
  parameters:
    alpha: '1e-2'
    reference: '0.5'
  states: {}
- name: satellites_decode_rs_0
  id: satellites_decode_rs
  parameters:
    basis: '0'
    verbose: 'True'
  states: {}
- name: satellites_decode_rs_0_0
  id: satellites_decode_rs
  parameters:
    basis: '0'
    verbose: 'True'
  states: {}
- name: satellites_decode_rs_0_0_0
  id: satellites_decode_rs
  parameters:
    basis: '0'
    verbose: 'True'
  states: {}
- name: satellites_kiss_to_pdu_0
  id: satellites_kiss_to_pdu
  parameters:
    control_byte: 'False'
  states: {}
- name: satellites_kiss_to_pdu_0_0
  id: satellites_kiss_to_pdu
  parameters:
    control_byte: 'False'
  states: {}
- name: satellites_kiss_to_pdu_0_1
  id: satellites_kiss_to_pdu
  parameters:
    control_byte: 'False'
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '40908'
    source: callsign
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: sync_to_pdu_0
  id: sync_to_pdu
  parameters:
    packlen: (114+32)*8
    sync: '"00011010110011111111110000011101"'
    threshold: threshold
  states: {}
- name: sync_to_pdu_0_0
  id: sync_to_pdu
  parameters:
    packlen: (114+32)*8
    sync: '"00011010110011111111110000011101"'
    threshold: threshold
  states: {}
- name: sync_to_pdu_0_0_0
  id: sync_to_pdu
  parameters:
    packlen: (114+32)*8
    sync: '"00011010110011111111110000011101"'
    threshold: threshold
  states: {}
- name: sync_to_pdu_0_1
  id: sync_to_pdu
  parameters:
    packlen: (114+32)*8
    sync: '"00011010110011111111110000011101"'
    threshold: threshold
  states: {}
- name: sync_to_pdu_0_1_0
  id: sync_to_pdu
  parameters:
    packlen: (114+32)*8
    sync: '"00011010110011111111110000011101"'
    threshold: threshold
  states: {}

connections:
- [analog_nbfm_rx_0, '0', low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_delay_0_0, '0']
- [blocks_complex_to_real_0, '0', ccsds_viterbi_0_1, '0']
- [blocks_delay_0_0, '0', ccsds_viterbi_0_0_0, '0']
- [blocks_delay_0_0_0, '0', ccsds_viterbi_0_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', satellites_kiss_to_pdu_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', satellites_kiss_to_pdu_0_0, '0']
- [blocks_pdu_to_tagged_stream_0_1, '0', satellites_kiss_to_pdu_0_1, '0']
- [ccsds_descrambler_0, out, satellites_decode_rs_0, in]
- [ccsds_descrambler_0_0, out, satellites_decode_rs_0_0, in]
- [ccsds_descrambler_0_0_0, out, satellites_decode_rs_0_0_0, in]
- [ccsds_viterbi_0, '0', sync_to_pdu_0_1_0, '0']
- [ccsds_viterbi_0_0, '0', sync_to_pdu_0_0_0, '0']
- [ccsds_viterbi_0_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [ccsds_viterbi_0_1, '0', digital_diff_decoder_bb_0, '0']
- [dc_blocker_xx_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [digital_binary_slicer_fb_1, '0', sync_to_pdu_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_delay_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', ccsds_viterbi_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_lms_dd_equalizer_cc_0_0, '0']
- [digital_diff_decoder_bb_0, '0', sync_to_pdu_0_1, '0']
- [digital_diff_decoder_bb_0_0, '0', sync_to_pdu_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_lms_dd_equalizer_cc_0_0, '0', blocks_complex_to_real_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_binary_slicer_fb_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', low_pass_filter_3_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', rms_agc_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_3_0_0, '0', analog_nbfm_rx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [rms_agc_0, '0', digital_fll_band_edge_cc_0, '0']
- [satellites_decode_rs_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_decode_rs_0_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [satellites_decode_rs_0_0_0, out, blocks_pdu_to_tagged_stream_0_1, pdus]
- [satellites_kiss_to_pdu_0, out, blocks_socket_pdu_0, pdus]
- [satellites_kiss_to_pdu_0, out, satellites_print_timestamp_0, in]
- [satellites_kiss_to_pdu_0, out, satellites_submit_0, in]
- [satellites_kiss_to_pdu_0_0, out, blocks_socket_pdu_0, pdus]
- [satellites_kiss_to_pdu_0_0, out, satellites_print_timestamp_0, in]
- [satellites_kiss_to_pdu_0_0, out, satellites_submit_0, in]
- [satellites_kiss_to_pdu_0_1, out, blocks_socket_pdu_0, pdus]
- [satellites_kiss_to_pdu_0_1, out, satellites_print_timestamp_0, in]
- [satellites_kiss_to_pdu_0_1, out, satellites_submit_0, in]
- [satellites_print_timestamp_0, out, blocks_message_debug_0, print_pdu]
- [sync_to_pdu_0, out, ccsds_descrambler_0, in]
- [sync_to_pdu_0_0, out, ccsds_descrambler_0_0, in]
- [sync_to_pdu_0_0_0, out, ccsds_descrambler_0_0_0, in]
- [sync_to_pdu_0_1, out, ccsds_descrambler_0_0, in]
- [sync_to_pdu_0_1_0, out, ccsds_descrambler_0_0_0, in]

metadata:
  file_format: 1
