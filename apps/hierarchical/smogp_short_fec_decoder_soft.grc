options:
  parameters:
    author: Daniel Estevez
    category: '[ao40]'
    description: SMOG-P short frame FEC decoder (soft symbols)
    generate_options: hb
    id: satellites_smogp_short_fec_decoder_soft
    output_language: python
    title: SMOG-P short frame FEC decoder (soft symbols)
  states: {}

blocks:
- name: viterbi
  id: variable_cc_decoder_def
  parameters:
    framebits: '2572'
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: ccsds_descrambler_0
  id: ccsds_descrambler
  parameters: {}
  states: {}
- name: fec_async_decoder_0_0
  id: fec_async_decoder
  parameters:
    decoder: viterbi
    mtu: int(2572/8)
    rev_pack: 'False'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: satellites_decode_rs_0
  id: satellites_decode_rs
  parameters:
    basis: '0'
    verbose: 'True'
  states: {}
- name: satellites_distributed_syncframe_soft_0_0
  id: satellites_distributed_syncframe_soft
  parameters:
    step: '51'
    syncword: '1111111000011101111001011001001000000100010011000101'
    threshold: '8'
  states: {}
- name: satellites_matrix_deinterleaver_soft_0_0
  id: satellites_matrix_deinterleaver_soft
  parameters:
    cols: '52'
    output_size: '2572'
    output_skip: '80'
    rows: '51'
  states: {}

connections:
- [ccsds_descrambler_0, out, satellites_decode_rs_0, in]
- [fec_async_decoder_0_0, out, ccsds_descrambler_0, in]
- [pad_source_0, '0', satellites_distributed_syncframe_soft_0_0, '0']
- [satellites_decode_rs_0, out, pad_sink_0, in]
- [satellites_distributed_syncframe_soft_0_0, out, satellites_matrix_deinterleaver_soft_0_0, in]
- [satellites_matrix_deinterleaver_soft_0_0, out, fec_async_decoder_0_0, in]

metadata:
  file_format: 1
