options:
  parameters:
    author: Daniel Estevez
    category: '[ao40]'
    description: AO40 FEC decoder
    generate_options: hb
    id: satellites_ao40_fec_decoder
    output_language: python
    title: AO40 FEC decoder
  states: {}

blocks:
- name: viterbi
  id: variable_cc_decoder_def
  parameters:
    framebits: '5132'
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: ccsds_descrambler_0
  id: ccsds_descrambler
  parameters: {}
  states: {}
- name: fec_async_decoder_0
  id: fec_async_decoder
  parameters:
    decoder: viterbi
    mtu: int(5132/8)
    rev_pack: 'False'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: satellites_ao40_deinterleaver_0
  id: satellites_ao40_deinterleaver
  parameters: {}
  states: {}
- name: satellites_ao40_rs_decoder_0
  id: satellites_ao40_rs_decoder
  parameters:
    verbose: 'True'
  states: {}
- name: satellites_ao40_syncframe_0
  id: satellites_ao40_syncframe
  parameters:
    threshold: '8'
  states: {}

connections:
- [ccsds_descrambler_0, out, satellites_ao40_rs_decoder_0, in]
- [fec_async_decoder_0, out, ccsds_descrambler_0, in]
- [pad_source_0, '0', satellites_ao40_syncframe_0, '0']
- [satellites_ao40_deinterleaver_0, out, fec_async_decoder_0, in]
- [satellites_ao40_rs_decoder_0, out, pad_sink_0, in]
- [satellites_ao40_syncframe_0, out, satellites_ao40_deinterleaver_0, in]

metadata:
  file_format: 1
