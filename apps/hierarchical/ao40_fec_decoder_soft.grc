<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>satellites_ao40_fec_decoder_soft</value></param>
<param><key>author</key><value>Daniel Estevez</value></param>
<param><key>category</key><value>[ao40]</value></param>
<param><key>description</key><value>AO40 FEC decoder (soft symbols)</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>AO40 FEC decoder (soft symbols)</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>viterbi</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>5132</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79,-109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>ccsds_descrambler</key>
<param><key>id</key><value>ccsds_descrambler_0</value></param>
</block>
<block>
<key>fec_async_decoder</key>
<param><key>id</key><value>fec_async_decoder_0</value></param>
<param><key>decoder</key><value>viterbi</value></param>
<param><key>mtu</key><value>5132/8</value></param>
<param><key>rev_pack</key><value>False</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>satellites_ao40_deinterleaver_soft</key>
<param><key>id</key><value>satellites_ao40_deinterleaver_soft_0</value></param>
</block>
<block>
<key>satellites_ao40_rs_decoder</key>
<param><key>id</key><value>satellites_ao40_rs_decoder_0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>satellites_ao40_syncframe_soft</key>
<param><key>id</key><value>satellites_ao40_syncframe_soft_0</value></param>
<param><key>threshold</key><value>8</value></param>
</block>
<connection><source_block_id>ccsds_descrambler_0</source_block_id><sink_block_id>satellites_ao40_rs_decoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fec_async_decoder_0</source_block_id><sink_block_id>ccsds_descrambler_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>satellites_ao40_syncframe_soft_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_ao40_deinterleaver_soft_0</source_block_id><sink_block_id>fec_async_decoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_ao40_rs_decoder_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_ao40_syncframe_soft_0</source_block_id><sink_block_id>satellites_ao40_deinterleaver_soft_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
