options:
  parameters:
    author: Daniel Estevez
    category: '[ao40]'
    description: AO40 FEC decoder (soft symbols)
    generate_options: hb
    id: satellites_ao40_fec_decoder_soft
    output_language: python
    title: AO40 FEC decoder (soft symbols)
  states: {}

blocks:
- name: viterbi
  id: variable_cc_decoder_def
  parameters:
    framebits: '5132'
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: ccsds_descrambler_0
  id: ccsds_descrambler
  parameters: {}
  states: {}
- name: fec_async_decoder_0
  id: fec_async_decoder
  parameters:
    decoder: viterbi
    mtu: int(5132/8)
    rev_pack: 'False'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: satellites_ao40_rs_decoder_0
  id: satellites_ao40_rs_decoder
  parameters:
    verbose: 'True'
  states: {}
- name: satellites_distributed_syncframe_soft_0
  id: satellites_distributed_syncframe_soft
  parameters:
    step: '80'
    syncword: '11111110000111011110010110010010000001000100110001011101011011000'
    threshold: '8'
  states: {}
- name: satellites_matrix_deinterleaver_soft_0
  id: satellites_matrix_deinterleaver_soft
  parameters:
    cols: '65'
    output_size: '5132'
    output_skip: '65'
    rows: '80'
  states: {}

connections:
- [ccsds_descrambler_0, out, satellites_ao40_rs_decoder_0, in]
- [fec_async_decoder_0, out, ccsds_descrambler_0, in]
- [pad_source_0, '0', satellites_distributed_syncframe_soft_0, '0']
- [satellites_ao40_rs_decoder_0, out, pad_sink_0, in]
- [satellites_distributed_syncframe_soft_0, out, satellites_matrix_deinterleaver_soft_0, in]
- [satellites_matrix_deinterleaver_soft_0, out, fec_async_decoder_0, in]

metadata:
  file_format: 1
