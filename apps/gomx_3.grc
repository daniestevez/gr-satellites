options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: GOMX-3 decoder
    generate_options: no_gui
    id: gomx_3
    output_language: python
    run_options: run
    title: GOMX-3 decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"10010011000010110101000111011110"'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '6'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: invert*10
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767.0'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: ip
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.1'
    omega: '2.5'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.1'
    omega: '10'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x00'
  states: {}
- name: digital_descrambler_bb_0_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x00'
  states: {}
- name: invert
  id: parameter
  parameters:
    label: invert the waveform (-1 to invert)
    short_id: i
    type: intx
    value: '1'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: '::'
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: note_0
  id: note
  parameters:
    note: 19k2
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 4k8
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: recstart
  id: parameter
  parameters:
    label: start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)
    type: str
    value: ''
  states: {}
- name: satellites_adsb_kml_0
  id: satellites_adsb_kml
  parameters: {}
  states: {state: disabled}
- name: satellites_ax100_decode_0
  id: satellites_ax100_decode
  parameters:
    verbose: 'False'
  states: {}
- name: satellites_check_crc_0
  id: satellites_check_crc
  parameters:
    force: 'False'
    include_header: 'False'
    verbose: 'False'
  states: {}
- name: satellites_gomx3_beacon_parser_0
  id: satellites_gomx3_beacon_parser
  parameters: {}
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '40949'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: sync_to_pdu_packed_0
  id: sync_to_pdu_packed
  parameters:
    packlen: '256'
    sync: access_code
    threshold: threshold
  states: {}
- name: sync_to_pdu_packed_0_0
  id: sync_to_pdu_packed
  parameters:
    packlen: '256'
    sync: access_code
    threshold: threshold
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_descrambler_bb_0, '0']
- [digital_binary_slicer_fb_0_0, '0', digital_descrambler_bb_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_descrambler_bb_0, '0', sync_to_pdu_packed_0, '0']
- [digital_descrambler_bb_0_0, '0', sync_to_pdu_packed_0_0, '0']
- [satellites_ax100_decode_0, out, satellites_check_crc_0, in]
- [satellites_check_crc_0, ok, satellites_print_timestamp_0, in]
- [satellites_print_timestamp_0, out, satellites_adsb_kml_0, in]
- [satellites_print_timestamp_0, out, satellites_gomx3_beacon_parser_0, in]
- [satellites_print_timestamp_0, out, satellites_submit_0, in]
- [sync_to_pdu_packed_0, out, satellites_ax100_decode_0, in]
- [sync_to_pdu_packed_0_0, out, satellites_ax100_decode_0, in]

metadata:
  file_format: 1
