options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: SMOG-P decoder
    generate_options: no_gui
    id: smog_p
    output_language: python
    run_options: run
    title: SMOG-P decoder
  states: {}

blocks:
- name: gain_mu
  id: variable
  parameters:
    value: 0.175*3
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1e-20'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1e-20'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1e-20'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1e-20'
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: invert*10
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.0'
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.01'
    type: float
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.01'
    type: float
  states: {}
- name: blocks_rms_xx_0_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.01'
    type: float
  states: {}
- name: blocks_rms_xx_0_0_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.01'
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767.0'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: ip
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: 8*16
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: 8*16
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_0_0_0
  id: dc_blocker_xx
  parameters:
    length: 8*16
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_0_0_0_0
  id: dc_blocker_xx
  parameters:
    length: 8*16
    long_form: 'True'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: gain_mu
    gain_omega: 0.25*gain_mu*gain_mu
    mu: '0.5'
    omega: '7.68'
    omega_relative_limit: '0.001'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: gain_mu
    gain_omega: 0.25*gain_mu*gain_mu
    mu: '0.5'
    omega: 48000.0/5000
    omega_relative_limit: '0.001'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: gain_mu
    gain_omega: 0.25*gain_mu*gain_mu
    mu: '0.5'
    omega: 48000.0/12500
    omega_relative_limit: '0.001'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: gain_mu
    gain_omega: 0.25*gain_mu*gain_mu
    mu: '0.5'
    omega: 48000.0/5/2500
    omega_relative_limit: '0.001'
    type: float
  states: {}
- name: invert
  id: parameter
  parameters:
    label: invert the waveform (-1 to invert)
    short_id: i
    type: intx
    value: '1'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: '::'
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '700'
    decim: '5'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '50'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 700*4
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: 50*4
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 700*10
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: 50*10
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 700*2
    decim: '5'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: 50*2
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 1250 baud
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 5000 baud
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: 12500 baud
  states: {}
- name: note_0_0_1_0
  id: note
  parameters:
    note: 2500 baud
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: recstart
  id: parameter
  parameters:
    label: start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)
    type: str
    value: ''
  states: {}
- name: satellites_ao40_fec_decoder_soft_0
  id: satellites_ao40_fec_decoder_soft
  parameters: {}
  states: {}
- name: satellites_ao40_fec_decoder_soft_0_0
  id: satellites_ao40_fec_decoder_soft
  parameters: {}
  states: {}
- name: satellites_ao40_fec_decoder_soft_0_0_0
  id: satellites_ao40_fec_decoder_soft
  parameters: {}
  states: {}
- name: satellites_ao40_fec_decoder_soft_0_0_0_0
  id: satellites_ao40_fec_decoder_soft
  parameters: {}
  states: {}
- name: satellites_bme_submitter_0
  id: satellites_bme_submitter
  parameters:
    satellite: smogp
  states: {}
- name: satellites_decode_ra_code_0
  id: satellites_decode_ra_code
  parameters:
    size: '128'
  states: {}
- name: satellites_decode_ra_code_0_0
  id: satellites_decode_ra_code
  parameters:
    size: '256'
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_smogp_packet_filter_0
  id: satellites_smogp_packet_filter
  parameters: {}
  states: {}
- name: satellites_smogp_short_fec_decoder_soft_0
  id: satellites_smogp_short_fec_decoder_soft
  parameters: {}
  states: {}
- name: satellites_smogp_short_fec_decoder_soft_0_0
  id: satellites_smogp_short_fec_decoder_soft
  parameters: {}
  states: {}
- name: satellites_smogp_short_fec_decoder_soft_0_0_0
  id: satellites_smogp_short_fec_decoder_soft
  parameters: {}
  states: {}
- name: satellites_smogp_short_fec_decoder_soft_0_0_0_0
  id: satellites_smogp_short_fec_decoder_soft
  parameters: {}
  states: {}
- name: satellites_smogp_signalling_0
  id: satellites_smogp_signalling
  parameters: {}
  states: {}
- name: satellites_smogp_spectrum_save_0
  id: satellites_smogp_spectrum_save
  parameters:
    path: /tmp/
  states: {}
- name: satellites_smogp_telemetry_parser_0
  id: satellites_smogp_telemetry_parser
  parameters: {}
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '44832'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: sync_to_pdu_packed_0
  id: sync_to_pdu_packed
  parameters:
    packlen: 64-6+6
    sync: '''0010110111010100100101111111110111010011011110110000111100011111'''
    threshold: '8'
  states: {}
- name: sync_to_pdu_soft_0_0
  id: sync_to_pdu_soft
  parameters:
    packlen: 260 * 8
    sync: '''0010110111010100'''
    threshold: '0'
  states: {}
- name: sync_to_pdu_soft_0_0_0
  id: sync_to_pdu_soft
  parameters:
    packlen: 514 * 8
    sync: '''0010110111010100'''
    threshold: '0'
  states: {}
- name: sync_to_pdu_soft_0_0_0_0
  id: sync_to_pdu_soft
  parameters:
    packlen: 514 * 8
    sync: '''0010110111010100'''
    threshold: '0'
  states: {}
- name: sync_to_pdu_soft_0_0_0_0_0
  id: sync_to_pdu_soft
  parameters:
    packlen: 514 * 8
    sync: '''0010110111010100'''
    threshold: '0'
  states: {}
- name: sync_to_pdu_soft_0_0_0_0_0_0
  id: sync_to_pdu_soft
  parameters:
    packlen: 514 * 8
    sync: '''0010110111010100'''
    threshold: '0'
  states: {}
- name: sync_to_pdu_soft_0_0_1
  id: sync_to_pdu_soft
  parameters:
    packlen: 260 * 8
    sync: '''0010110111010100'''
    threshold: '0'
  states: {}
- name: sync_to_pdu_soft_0_0_1_0
  id: sync_to_pdu_soft
  parameters:
    packlen: 260 * 8
    sync: '''0010110111010100'''
    threshold: '0'
  states: {}
- name: sync_to_pdu_soft_0_0_1_0_0
  id: sync_to_pdu_soft
  parameters:
    packlen: 260 * 8
    sync: '''0010110111010100'''
    threshold: '0'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_divide_xx_0, '1']
- [blocks_add_const_vxx_0_0, '0', blocks_divide_xx_0_0, '1']
- [blocks_add_const_vxx_0_0_0, '0', blocks_divide_xx_0_0_0, '1']
- [blocks_add_const_vxx_0_0_0_0, '0', blocks_divide_xx_0_0_0_0, '1']
- [blocks_divide_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_divide_xx_0_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_divide_xx_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0, '0']
- [blocks_divide_xx_0_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', blocks_add_const_vxx_0_0_0_0, '0']
- [blocks_rms_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_rms_xx_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_rms_xx_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_rms_xx_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [dc_blocker_xx_0, '0', blocks_divide_xx_0, '0']
- [dc_blocker_xx_0, '0', blocks_rms_xx_0, '0']
- [dc_blocker_xx_0_0, '0', blocks_divide_xx_0_0, '0']
- [dc_blocker_xx_0_0_0, '0', blocks_divide_xx_0_0_0, '0']
- [dc_blocker_xx_0_0_0_0, '0', blocks_divide_xx_0_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', sync_to_pdu_packed_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', satellites_ao40_fec_decoder_soft_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', satellites_smogp_short_fec_decoder_soft_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', sync_to_pdu_soft_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', sync_to_pdu_soft_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', satellites_ao40_fec_decoder_soft_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', satellites_smogp_short_fec_decoder_soft_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', sync_to_pdu_soft_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', sync_to_pdu_soft_0_0_1, '0']
- [digital_clock_recovery_mm_xx_0_0_0, '0', satellites_ao40_fec_decoder_soft_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0, '0', satellites_smogp_short_fec_decoder_soft_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0, '0', sync_to_pdu_soft_0_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0, '0', sync_to_pdu_soft_0_0_1_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0, '0', satellites_ao40_fec_decoder_soft_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0, '0', satellites_smogp_short_fec_decoder_soft_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0, '0', sync_to_pdu_soft_0_0_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0, '0', sync_to_pdu_soft_0_0_1_0_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_0_0, '0', blocks_rms_xx_0_0, '0']
- [low_pass_filter_0_0, '0', dc_blocker_xx_0_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_rms_xx_0_0_0, '0']
- [low_pass_filter_0_0_0, '0', dc_blocker_xx_0_0_0, '0']
- [low_pass_filter_0_0_0_0, '0', blocks_rms_xx_0_0_0_0, '0']
- [low_pass_filter_0_0_0_0, '0', dc_blocker_xx_0_0_0_0, '0']
- [satellites_ao40_fec_decoder_soft_0, out, satellites_print_timestamp_0, in]
- [satellites_ao40_fec_decoder_soft_0_0, out, satellites_print_timestamp_0, in]
- [satellites_ao40_fec_decoder_soft_0_0_0, out, satellites_print_timestamp_0, in]
- [satellites_ao40_fec_decoder_soft_0_0_0_0, out, satellites_print_timestamp_0, in]
- [satellites_decode_ra_code_0, out, satellites_smogp_packet_filter_0, in]
- [satellites_decode_ra_code_0_0, out, satellites_smogp_packet_filter_0, in]
- [satellites_print_timestamp_0, out, blocks_message_debug_0, print_pdu]
- [satellites_print_timestamp_0, out, satellites_bme_submitter_0, in]
- [satellites_print_timestamp_0, out, satellites_smogp_spectrum_save_0, in]
- [satellites_print_timestamp_0, out, satellites_smogp_telemetry_parser_0, in]
- [satellites_print_timestamp_0, out, satellites_submit_0, in]
- [satellites_smogp_packet_filter_0, out, satellites_print_timestamp_0, in]
- [satellites_smogp_short_fec_decoder_soft_0, out, satellites_print_timestamp_0, in]
- [satellites_smogp_short_fec_decoder_soft_0_0, out, satellites_print_timestamp_0, in]
- [satellites_smogp_short_fec_decoder_soft_0_0_0, out, satellites_print_timestamp_0, in]
- [satellites_smogp_short_fec_decoder_soft_0_0_0_0, out, satellites_print_timestamp_0, in]
- [sync_to_pdu_packed_0, out, satellites_smogp_signalling_0, in]
- [sync_to_pdu_soft_0_0, out, satellites_decode_ra_code_0, in]
- [sync_to_pdu_soft_0_0_0, out, satellites_decode_ra_code_0_0, in]
- [sync_to_pdu_soft_0_0_0_0, out, satellites_decode_ra_code_0_0, in]
- [sync_to_pdu_soft_0_0_0_0_0, out, satellites_decode_ra_code_0_0, in]
- [sync_to_pdu_soft_0_0_0_0_0_0, out, satellites_decode_ra_code_0_0, in]
- [sync_to_pdu_soft_0_0_1, out, satellites_decode_ra_code_0, in]
- [sync_to_pdu_soft_0_0_1_0, out, satellites_decode_ra_code_0, in]
- [sync_to_pdu_soft_0_0_1_0_0, out, satellites_decode_ra_code_0, in]

metadata:
  file_format: 1
