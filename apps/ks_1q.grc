options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: KS-1Q decoder
    generate_options: no_gui
    id: ks_1q
    output_language: python
    run_options: run
    title: KS-1Q decoder
  states: {}

blocks:
- name: threshold
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: invert*10
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767.0'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: ip
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: ccsds_descrambler_0
  id: ccsds_descrambler
  parameters: {}
  states: {}
- name: ccsds_viterbi_0
  id: ccsds_viterbi
  parameters: {}
  states: {}
- name: ccsds_viterbi_0_0
  id: ccsds_viterbi
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: '2.4'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: invert
  id: parameter
  parameters:
    label: invert the waveform (-1 to invert)
    short_id: i
    type: intx
    value: '1'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: '::'
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 11e3
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 20k
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: recstart
  id: parameter
  parameters:
    label: start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)
    type: str
    value: ''
  states: {}
- name: satellites_check_crc_0_0
  id: satellites_check_crc
  parameters:
    force: 'True'
    include_header: 'False'
    verbose: 'False'
  states: {}
- name: satellites_decode_rs_0
  id: satellites_decode_rs
  parameters:
    basis: '1'
    verbose: 'True'
  states: {}
- name: satellites_kiss_to_pdu_0_0
  id: satellites_kiss_to_pdu
  parameters:
    control_byte: 'True'
  states: {}
- name: satellites_ks1q_header_remover_0
  id: satellites_ks1q_header_remover
  parameters: {}
  states: {}
- name: satellites_print_header_0_0
  id: satellites_print_header
  parameters: {}
  states: {state: disabled}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '41845'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: satellites_swap_header_0_0
  id: satellites_swap_header
  parameters: {}
  states: {}
- name: sync_to_pdu_0
  id: sync_to_pdu
  parameters:
    packlen: 255*8
    sync: '"00011010110011111111110000011101"'
    threshold: threshold
  states: {}
- name: sync_to_pdu_0_0
  id: sync_to_pdu
  parameters:
    packlen: 255*8
    sync: '"00011010110011111111110000011101"'
    threshold: threshold
  states: {}

connections:
- [blocks_delay_0, '0', ccsds_viterbi_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', satellites_kiss_to_pdu_0_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [ccsds_descrambler_0, out, satellites_decode_rs_0, in]
- [ccsds_viterbi_0, '0', sync_to_pdu_0, '0']
- [ccsds_viterbi_0_0, '0', sync_to_pdu_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_delay_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', ccsds_viterbi_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [satellites_check_crc_0_0, ok, satellites_swap_header_0_0, in]
- [satellites_decode_rs_0, out, satellites_ks1q_header_remover_0, in]
- [satellites_decode_rs_0, out, satellites_submit_0, in]
- [satellites_kiss_to_pdu_0_0, out, satellites_check_crc_0_0, in]
- [satellites_ks1q_header_remover_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_print_timestamp_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_print_timestamp_0, out, satellites_print_header_0_0, in]
- [satellites_swap_header_0_0, out, satellites_print_timestamp_0, in]
- [sync_to_pdu_0, out, ccsds_descrambler_0, in]
- [sync_to_pdu_0_0, out, ccsds_descrambler_0, in]

metadata:
  file_format: 1
