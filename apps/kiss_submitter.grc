options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: KISS client telemetry submitter
    generate_options: no_gui
    id: kiss_submitter
    output_language: python
    run_options: run
    title: KISS client telemetry submitter
  states: {}

blocks:
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: host
    mtu: '10000'
    port: port
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: host
  id: parameter
  parameters:
    label: Host
    value: localhost
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: norad
  id: parameter
  parameters:
    label: NORAD ID
    type: intx
    value: '0'
  states: {}
- name: port
  id: parameter
  parameters:
    label: Port
    short_id: p
    value: '8001'
  states: {}
- name: recstart
  id: parameter
  parameters:
    label: start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)
    type: str
    value: ''
  states: {}
- name: satellites_kiss_to_pdu_0
  id: satellites_kiss_to_pdu
  parameters:
    control_byte: 'True'
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: norad
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', satellites_kiss_to_pdu_0, '0']
- [blocks_socket_pdu_0, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_kiss_to_pdu_0, out, satellites_submit_0, in]

metadata:
  file_format: 1
