options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: D-SAT decoder
    generate_options: no_gui
    id: dsat
    output_language: python
    run_options: run
    title: D-SAT decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"11000011101010100110011001010101"'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-3600'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767.0'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '50000'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: ip
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '10'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: '::'
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2600'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 4k8
  states: {}
- name: note_1
  id: note
  parameters:
    note: Output to Groundstation software
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: recstart
  id: parameter
  parameters:
    label: start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)
    type: str
    value: ''
  states: {}
- name: satellites_append_crc32c_0
  id: satellites_append_crc32c
  parameters:
    include_header: 'False'
  states: {}
- name: satellites_dsat_image_decoder_0
  id: satellites_dsat_image_decoder
  parameters:
    display: 'True'
    fullscreen: 'True'
    path: /tmp/
  states: {}
- name: satellites_pdu_to_kiss_0
  id: satellites_pdu_to_kiss
  parameters: {}
  states: {}
- name: satellites_print_header_0
  id: satellites_print_header
  parameters: {}
  states: {state: disabled}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '42794'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: satellites_swap_header_0
  id: satellites_swap_header
  parameters: {}
  states: {}
- name: satellites_u482c_decode_0
  id: satellites_u482c_decode
  parameters:
    rs: '-1'
    scrambler: '-1'
    viterbi: '-1'
  states: {}
- name: sync_to_pdu_packed_0
  id: sync_to_pdu_packed
  parameters:
    packlen: 255+3
    sync: access_code
    threshold: threshold
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_conjugate_cc_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [digital_gmsk_demod_0, '0', sync_to_pdu_packed_0, '0']
- [low_pass_filter_0, '0', digital_gmsk_demod_0, '0']
- [satellites_append_crc32c_0, out, satellites_pdu_to_kiss_0, in]
- [satellites_pdu_to_kiss_0, out, blocks_socket_pdu_0, pdus]
- [satellites_print_timestamp_0, out, blocks_message_debug_0, print_pdu]
- [satellites_print_timestamp_0, out, satellites_dsat_image_decoder_0, in]
- [satellites_print_timestamp_0, out, satellites_print_header_0, in]
- [satellites_print_timestamp_0, out, satellites_swap_header_0, in]
- [satellites_swap_header_0, out, satellites_append_crc32c_0, in]
- [satellites_u482c_decode_0, out, satellites_print_timestamp_0, in]
- [satellites_u482c_decode_0, out, satellites_submit_0, in]
- [sync_to_pdu_packed_0, out, satellites_u482c_decode_0, in]

metadata:
  file_format: 1
