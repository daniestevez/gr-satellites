<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>generic_1k2_afsk_ax25</value></param>
<param><key>author</key><value>Daniel Estevez</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Generic 1k2 AFSK AX.25 decoder</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Generic 1k2 AFSK AX.25 decoder</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_mu</value></param>
<param><key>value</key><value>0.175*3</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>lowpass_taps</value></param>
<param><key>cutoff_freq</key><value>1200</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>0.3</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>32767.0</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>True</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>ip</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>port</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>callsign</value></param>
<param><key>label</key><value>your callsign</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>gain_mu</value></param>
<param><key>gain_omega</key><value>0.25*gain_mu*gain_mu</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>(1200+2200)*0.5</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>taps</key><value>lowpass_taps</value></param>
<param><key>type</key><value>fcf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ip</value></param>
<param><key>label</key><value>UDP listen IP</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>::</value></param>
</block>
<block>
<key>satellites_hdlc_deframer</key>
<param><key>id</key><value>satellites_hdlc_deframer_0</value></param>
<param><key>check_fcs</key><value>True</value></param>
<param><key>max_length</key><value>10000</value></param>
</block>
<block>
<key>satellites_nrzi_decode</key>
<param><key>id</key><value>satellites_nrzi_decode_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>latitude</value></param>
<param><key>label</key><value>latitude (format 00.000 or -00.000)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>longitude</value></param>
<param><key>label</key><value>longitude (format 00.000 or -00.000)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>1200</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>4800</value></param>
<param><key>width</key><value>200</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>norad_id</value></param>
<param><key>label</key><value>NORAD ID</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>99999</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>UDP port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7355</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>recstart</value></param>
<param><key>label</key><value>start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>satellites_pdu_to_kiss</key>
<param><key>id</key><value>satellites_pdu_to_kiss_0</value></param>
</block>
<block>
<key>satellites_print_timestamp</key>
<param><key>id</key><value>satellites_print_timestamp_0</value></param>
<param><key>fmt</key><value>%Y-%m-%d %H:%M:%S</value></param>
<param><key>count</key><value>True</value></param>
</block>
<block>
<key>satellites_submit</key>
<param><key>id</key><value>satellites_submit_0</value></param>
<param><key>latitude</key><value>latitude</value></param>
<param><key>longitude</key><value>longitude</value></param>
<param><key>noradID</key><value>norad_id</value></param>
<param><key>source</key><value>callsign</value></param>
<param><key>tstamp</key><value>recstart</value></param>
<param><key>url</key><value>https://db.satnogs.org/api/telemetry/</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>satellites_nrzi_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_hdlc_deframer_0</source_block_id><sink_block_id>satellites_print_timestamp_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_nrzi_decode_0</source_block_id><sink_block_id>satellites_hdlc_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_pdu_to_kiss_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>satellites_print_timestamp_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>satellites_print_timestamp_0</source_block_id><sink_block_id>satellites_pdu_to_kiss_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_print_timestamp_0</source_block_id><sink_block_id>satellites_submit_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
