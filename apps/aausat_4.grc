options:
  parameters:
    author: Daniel Estevez
    category: Custom
    description: AAUSAT-4 decoder
    generate_options: no_gui
    id: aausat_4
    output_language: python
    run_options: run
    title: AAUSAT-4 decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '"010011110101101000110100010000110101010101000010"'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '8'
  states: {}
- name: viterbi_long
  id: variable_cc_decoder_def
  parameters:
    framebits: '1996'
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: viterbi_short
  id: variable_cc_decoder_def
  parameters:
    framebits: '1020'
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: invert*10
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767.0'
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '8'
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: ip
    port: port
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: your callsign
    type: str
    value: ''
  states: {}
- name: ccsds_descrambler_0
  id: ccsds_descrambler
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.005'
    omega: '20.0'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.005'
    omega: '5.0'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: fec_async_decoder_0
  id: fec_async_decoder
  parameters:
    decoder: viterbi_long
    mtu: int(1996/8)
    rev_pack: 'False'
  states: {}
- name: fec_async_decoder_0_0
  id: fec_async_decoder
  parameters:
    decoder: viterbi_short
    mtu: int(1020/8)
    packed: 'True'
    rev_pack: 'False'
  states: {}
- name: invert
  id: parameter
  parameters:
    label: invert the waveform (-1 to invert)
    short_id: i
    type: intx
    value: '1'
  states: {}
- name: ip
  id: parameter
  parameters:
    label: UDP listen IP
    type: str
    value: '::'
  states: {}
- name: latitude
  id: parameter
  parameters:
    label: latitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: longitude (format 00.000 or -00.000)
    type: eng_float
    value: '0'
  states: {}
- name: note_0
  id: note
  parameters:
    note: 2k4
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 9k6
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'Workaround: this segfauls in unpacked mode'
  states: {}
- name: port
  id: parameter
  parameters:
    label: UDP port
    type: intx
    value: '7355'
  states: {}
- name: recstart
  id: parameter
  parameters:
    label: start of recording, if processing a recording (format YYYY-MM-DD HH:MM:SS)
    type: str
    value: ''
  states: {}
- name: satellites_aausat4_check_fsm_0
  id: satellites_aausat4_check_fsm
  parameters: {}
  states: {}
- name: satellites_aausat4_telemetry_parser_0
  id: satellites_aausat4_telemetry_parser
  parameters: {}
  states: {}
- name: satellites_decode_rs_0
  id: satellites_decode_rs
  parameters:
    basis: '0'
    verbose: 'True'
  states: {}
- name: satellites_print_header_0
  id: satellites_print_header
  parameters: {}
  states: {state: disabled}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: latitude
    longitude: longitude
    noradID: '41460'
    source: callsign
    tstamp: recstart
    url: https://db.satnogs.org/api/telemetry/
  states: {}
- name: sync_to_pdu_soft_0
  id: sync_to_pdu_soft
  parameters:
    packlen: 1996+8
    sync: access_code
    threshold: threshold
  states: {}
- name: sync_to_pdu_soft_0_0
  id: sync_to_pdu_soft
  parameters:
    packlen: 1996+8
    sync: access_code
    threshold: threshold
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_tagged_stream_multiply_length_0_0_0_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_tagged_stream_multiply_length_0_0_0_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, ccsds_descrambler_0, in]
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [ccsds_descrambler_0, out, satellites_decode_rs_0, in]
- [digital_clock_recovery_mm_xx_0, '0', sync_to_pdu_soft_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', sync_to_pdu_soft_0_0, '0']
- [fec_async_decoder_0, out, ccsds_descrambler_0, in]
- [fec_async_decoder_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_aausat4_check_fsm_0, long, fec_async_decoder_0, in]
- [satellites_aausat4_check_fsm_0, short, fec_async_decoder_0_0, in]
- [satellites_decode_rs_0, out, satellites_print_timestamp_0, in]
- [satellites_print_timestamp_0, out, satellites_aausat4_telemetry_parser_0, in]
- [satellites_print_timestamp_0, out, satellites_print_header_0, in]
- [satellites_print_timestamp_0, out, satellites_submit_0, in]
- [sync_to_pdu_soft_0, out, satellites_aausat4_check_fsm_0, in]
- [sync_to_pdu_soft_0_0, out, satellites_aausat4_check_fsm_0, in]

metadata:
  file_format: 1
